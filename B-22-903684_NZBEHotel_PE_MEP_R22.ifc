Properties of the parts of a building model (IFC2X3), part 6 of 7

# IfcFlowSegment: Pipe Types:AMB.LAM.Tuberia.PEX (168)
Name (Pipe Types:AMB.LAM.Tuberia.PEX:...) | In | Pset_FlowSegmentDuctSegment, Length (cm) = Pset_FlowSegmentPipeSegment, Length (cm) = 501.AMB.Longitud (cm) | InvertElevation (cm) | 112.AMB.Servei | 115.AMB.Nivell | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (cm) | Group
3704435 | P0 | 152.548 | 292.45 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0958489 | 2 | IF.FONT.AFS 5
3704459 | P0 | 211.75 | 79.5 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.133046 | 2 | IF.FONT.AFS 5
3704468 | P0 | 211.375 | 79.5 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.132811 | 2 | IF.FONT.AFS 5
3704471 | P0 | 13.0828 | 292.45 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.00822016 | 2 | IF.FONT.AFS 5
3704557 | P0 | 204.466 | 295.2 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø | 0.12847 | 2 | IF.FONT.ACS 2
3704574 | P0 | 214.5 | 79 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø | 0.134774 | 2 | IF.FONT.ACS 2
3704601 | P0 | 129.5 | 295.2 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø | 0.0813672 | 2 | IF.FONT.ACS 2
3704676 | P0 | 48.387 | 295.2 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø | 0.0304024 | 2 | IF.FONT.ACS 2
3704718 | P0 | 76.4287 | 292.45 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0480216 | 2 | IF.FONT.AFS 5
3704775 | P0 | 142.772 | 295.2 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø | 0.0897065 | 2 | IF.FONT.ACS 2
3704830 | P0 | 199.639 | 295.2 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø | 0.125437 | 2 | IF.FONT.ACS 2
3704836 | P0 | 234.09 | 291.95 | Piping System: IF.FONT.AFS | Level: P0 | 32 mmø | 0.235333 | 3.2 | IF.FONT.AFS 5
3704863 | P0 | 64.2866 | 292.45 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0403924 | 2 | IF.FONT.AFS 5
3704880 | P0 | 211.75 | 79 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.133046 | 2 | IF.FONT.AFS 5
3704889 | P0 | 211.75 | 79.5 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.133046 | 2 | IF.FONT.AFS 5
3704913 | P0 | 51.1454 | 292.45 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0321356 | 2 | IF.FONT.AFS 5
3704922 | P0 | 16.2134 | 292.45 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0101872 | 2 | IF.FONT.AFS 5
3704925 | P0 | 30.1208 | 292.45 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0189255 | 2 | IF.FONT.AFS 5
3704945 | P0 | 4.58097 | 292.45 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.00287831 | 2 | IF.FONT.AFS 5
3704976 | P0 | 18.461 | 292.45 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0115994 | 2 | IF.FONT.AFS 5
3705051 | P0 | 5.00379 | 295.325 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø | 0.00314397 | 2 | IF.FONT.ACS 2
3705085 | P0 | 87.7978 | 292.575 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.055165 | 2 | IF.FONT.AFS 5
3706659 | P0 | 26.9264 | 172 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø | 0.0169184 | 2 | IF.FONT.ACS 2
3707891 | P0 | 36.9264 | 162 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0232016 | 2 | IF.FONT.AFS 5
3707930 | P0 | 46.6601 | 292.575 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0293174 | 2 | IF.FONT.AFS 5
3707966 | P0 | 13.5 | 295.2 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø | 0.0084823 | 2 | IF.FONT.ACS 2
3708135 | S1 | 28.9932 | 169.2 | Piping System: IF.FONT.ACS | Level: S1 | 20 mmø | 0.0182169 | 2 | IF.FONT.ACS 2
3708178 | S1 | 5.45902 | 169.2 | Piping System: IF.FONT.ACS | Level: S1 | 20 mmø | 0.00343 | 2 | IF.FONT.ACS 2
3708215 | S1 | 34.3429 | 159.2 | Piping System: IF.FONT.AFS | Level: S1 | 20 mmø | 0.0215783 | 2 | IF.FONT.AFS 5
3708324 | S1 | 121.5 | 172.5 | Piping System: IF.FONT.ACS | Level: S1 | 20 mmø | 0.0763407 | 2 | IF.FONT.ACS 2
3708345 | S1 | 128.375 | 162.5 | Piping System: IF.FONT.AFS | Level: S1 | 20 mmø | 0.0806604 | 2 | IF.FONT.AFS 5
3708358 | P0 | 8.50021 | 292.45 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.00534084 | 2 | IF.FONT.AFS 5
3709529 | P1 | 201.835 | 646.7 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.126817 | 2 | IF.FONT.AFS 5
3709539 | P1 | 23.9995 | 426.2 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.0150793 | 2 | IF.FONT.AFS 5
3709540 | P1 | 216.5 | 429 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.136031 | 2 | IF.FONT.AFS 5
3709543 | P1 | 23.3133 | 426.2 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.0146482 | 2 | IF.FONT.AFS 5
3709544 | P1 | 216 | 429 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.135717 | 2 | IF.FONT.AFS 5
3709547 | P1 | 22.787 | 426.2 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.0143175 | 2 | IF.FONT.AFS 5
3709548 | P1 | 216 | 429 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.135717 | 2 | IF.FONT.AFS 5
3709556 | P1 | 55.2972 | 646.7 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.0347443 | 2 | IF.FONT.AFS 5
3709562 | P1 | 48.0973 | 646.7 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.0302204 | 2 | IF.FONT.AFS 5
3709567 | P1 | 21.8254 | 426.2 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.0137133 | 2 | IF.FONT.AFS 5
3709569 | P1 | 20.1469 | 426.2 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.0126587 | 2 | IF.FONT.AFS 5
3709571 | P1 | 17.0448 | 426.2 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.0107096 | 2 | IF.FONT.AFS 5
3709573 | P1 | 30.099 | 426.2 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.0189118 | 2 | IF.FONT.AFS 5
3709575 | P1 | 28.6115 | 426.2 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.0179771 | 2 | IF.FONT.AFS 5
3709579 | P1 | 215.5 | 429.5 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.135403 | 2 | IF.FONT.AFS 5
3709582 | P1 | 21.191 | 646.7 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.0133147 | 2 | IF.FONT.AFS 5
3709587 | P1 | 215.5 | 429.5 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.135403 | 2 | IF.FONT.AFS 5
3709590 | P1 | 180.717 | 646.7 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.113548 | 2 | IF.FONT.AFS 5
3709597 | P1 | 211.3 | 429.5 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.132764 | 2 | IF.FONT.AFS 5
3709600 | P1 | 109.81 | 646.5 | Piping System: IF.FONT.AFS | Level: P1 | 25 mmø | 0.0862446 | 2.5 | IF.FONT.AFS 5
3709607 | P1 | 60.0296 | 646.7 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.0377177 | 2 | IF.FONT.AFS 5
3709609 | P1 | 216 | 429 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.135717 | 2 | IF.FONT.AFS 5
3709613 | P1 | 51.3339 | 646.5 | Piping System: IF.FONT.AFS | Level: P1 | 25 mmø | 0.0403176 | 2.5 | IF.FONT.AFS 5
3709618 | P1 | 11.6967 | 646.5 | Piping System: IF.FONT.AFS | Level: P1 | 25 mmø | 0.0091866 | 2.5 | IF.FONT.AFS 5
3709627 | P1 | 210.1 | 429.5 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.13201 | 2 | IF.FONT.AFS 5
3709630 | P1 | 227.807 | 646.2 | Piping System: IF.FONT.AFS | Level: P1 | 32 mmø | 0.229016 | 3.2 | IF.FONT.AFS 5
3709996 | P1 | 338.811 | 646.7 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.212881 | 2 | IF.FONT.AFS 5
3710004 | P1 | 115.647 | 646.7 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.0726629 | 2 | IF.FONT.AFS 5
3710015 | P1 | 332.609 | 646.7 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.208984 | 2 | IF.FONT.AFS 5
3710042 | P1 | 303.027 | 649.2 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø | 0.190397 | 2 | IF.FONT.ACS 4
3710051 | P1 | 114.161 | 649.2 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø | 0.0717298 | 2 | IF.FONT.ACS 4
3710062 | P1 | 23.0301 | 649.2 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø | 0.0144702 | 2 | IF.FONT.ACS 4
3710174 | P1 | 29.5 | 426.2 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.0185354 | 2 | IF.FONT.AFS 5
3710199 | P1 | 29.5 | 426.2 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø | 0.0185354 | 2 | IF.FONT.ACS 4
3710441 | P1 | 15.1397 | 646.7 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.00951253 | 2 | IF.FONT.AFS 5
3710443 | P1 | 11.4835 | 649.2 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø | 0.00721527 | 2 | IF.FONT.ACS 4
3710485 | P1 | 218.5 | 429 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø | 0.137288 | 2 | IF.FONT.ACS 4
3710518 | P1 | 216 | 429 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.135717 | 2 | IF.FONT.AFS 5
3710620 | P1 | 34.1759 | 426.2 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.0214733 | 2 | IF.FONT.AFS 5
3710622 | P1 | 36.5609 | 426.2 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø | 0.0229719 | 2 | IF.FONT.ACS 4
3710740 | P1 | 43.8227 | 646.5 | Piping System: IF.FONT.AFS | Level: P1 | 25 mmø | 0.0344183 | 2.5 | IF.FONT.AFS 5
3710769 | P1 | 40.9421 | 649.2 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø | 0.0257247 | 2 | IF.FONT.ACS 4
3710820 | P1 | 211.8 | 432.7 | Piping System: IF.FONT.AFS | Level: P1 | 25 mmø | 0.166347 | 2.5 | IF.FONT.AFS 5
3710853 | P1 | 218.5 | 429 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø | 0.137288 | 2 | IF.FONT.ACS 4
3710876 | P1 | 151.167 | 646.5 | Piping System: IF.FONT.AFS | Level: P1 | 25 mmø | 0.118726 | 2.5 | IF.FONT.AFS 5
3710945 | P1 | 9.58287 | 646.7 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.00602109 | 2 | IF.FONT.AFS 5
3710954 | P1 | 83.7729 | 646.5 | Piping System: IF.FONT.AFS | Level: P1 | 25 mmø | 0.0657951 | 2.5 | IF.FONT.AFS 5
3711010 | P1 | 13.2773 | 649.2 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø | 0.00834235 | 2 | IF.FONT.ACS 4
3711021 | P1 | 16.904 | 649.2 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø | 0.0106211 | 2 | IF.FONT.ACS 4
3711069 | P1 | 748.228 | 649.2 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø | 0.470126 | 2 | IF.FONT.ACS 4
3712245 | P1 | 18.1664 | 510.76 | Piping System: IF.FONT.AFS | Level: P1 | 16 mmø | 0.00913144 | 1.6 | IF.FONT.AFS 5
3712268 | P1 | 13.1664 | 515.76 | Piping System: IF.FONT.ACS | Level: P1 | 16 mmø | 0.00661817 | 1.6 | IF.FONT.ACS 4
3712287 | P1 | 10.8254 | 508.2 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.00680181 | 2 | IF.FONT.AFS 5
3712402 | P1 | 16.9193 | 513.2 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø | 0.0106307 | 2 | IF.FONT.ACS 4
3712449 | P1 | 131.5 | 516 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø | 0.0826239 | 2 | IF.FONT.ACS 4
3712494 | P1 | 134 | 511.5 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.0841947 | 2 | IF.FONT.AFS 5
3712545 | P1 | 5.50379 | 508.2 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.00345813 | 2 | IF.FONT.AFS 5
3712575 | P1 | 19.5783 | 649.2 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø | 0.0123014 | 2 | IF.FONT.ACS 4
3712603 | P1 | 14.5201 | 649.2 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø | 0.00912326 | 2 | IF.FONT.ACS 4
3712619 | P1 | 21.1212 | 646.7 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø | 0.0132708 | 2 | IF.FONT.AFS 5
3712657 | P1 | 7.98327 | 645.75 | Piping System: IF.FONT.AFS | Level: P1 | 40 mmø | 0.0100321 | 4 | IF.FONT.AFS 5
3712680 | P1 | 14.7443 | 645.75 | Piping System: IF.FONT.AFS | Level: P1 | 40 mmø | 0.0185282 | 4 | IF.FONT.AFS 5
3712689 | P1 | 18.6337 | 645.75 | Piping System: IF.FONT.AFS | Level: P1 | 40 mmø | 0.0234158 | 4 | IF.FONT.AFS 5
3712708 | P1 | 28.1937 | 645.75 | Piping System: IF.FONT.AFS | Level: P1 | 40 mmø | 0.0354292 | 4 | IF.FONT.AFS 5
3775097 | P0 | 14.3222 | 265.7 | Piping System: IF.FONT.AFS | Level: P0 | 32 mmø | 0.0143982 | 3.2 | IF.FONT.AFS 5
3775374 | P0 | 19.575 | 270.6 | Piping System: IF.FONT.AFS | Level: P0 | 32 mmø | 0.0196789 | 3.2 | IF.FONT.AFS 5
3783595 | P0 | 161.499 | 291 | Piping System: IF.FONT.AFS | Level: P0 | 50 mmø | 0.253682 | 5 | IF.FONT.AFS 5
3783613 | P0 | 166.394 | 291 | Piping System: IF.FONT.AFS | Level: P0 | 50 mmø | 0.261371 | 5 | IF.FONT.AFS 5

# IfcFlowSegment: Pipe Types:AMB.LAM.Tubería.PEAD_PN25 (14)
In: P0
Type - Pset_ProductRequirements - Category: Pipes
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.30; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigua sanitària; 109.AMB.CodiTipus: LAM16; 111.AMB.DescripcioTipus: Tubeira distribució aigua de PEAD PN25
Classification: 50.10.20.30 Canalitzacions d'aigua sanitària (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:AMB.LAM.Tubería.PEAD_PN25; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.0007 cm
1 AMB.Identificacio - 107.AMB.NomTipus: Pipe Types: AMB.LAM.Tubería.PEAD_PN25; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
Name (Pipe Types:AMB.LAM.Tubería.PEAD_PN25:...) | Pset_FlowSegmentDuctSegment, Length (cm) = Pset_FlowSegmentPipeSegment, Length (cm) = 501.AMB.Longitud (cm) | InvertElevation (cm) | 112.AMB.Servei | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (cm) | Group
3403681 | 1261.91 | -35.71 | Piping System: IF.EXTI.BIEs | 75 mmø | 2.9733 | 7.5 | IF.EXTI.BIEs 5
3403712 | 899.971 | -35.71 | Piping System: IF.EXTI.BIEs | 75 mmø | 2.12051 | 7.5 | IF.EXTI.BIEs 5
3403720 | 185.312 | -35.71 | Piping System: IF.EXTI.BIEs | 75 mmø | 0.436632 | 7.5 | IF.EXTI.BIEs 5
3403737 | 275.775 | -35.71 | Piping System: IF.EXTI.BIEs | 75 mmø | 0.64978 | 7.5 | IF.EXTI.BIEs 5
3415986 | 24.4753 | -35.71 | Piping System: IF.EXTI.BIEs | 75 mmø | 0.0576686 | 7.5 | IF.EXTI.BIEs 5
3416067 | 63.3811 | -35.71 | Piping System: IF.EXTI.BIEs | 75 mmø | 0.149338 | 7.5 | IF.EXTI.BIEs 5
3419661 | 13.5056 | -35.71 | Piping System: IF.EXTI.BIEs | 75 mmø | 0.0318219 | 7.5 | IF.EXTI.BIEs 5
3701156 | 1267.53 | -35.28 | Piping System: IF.FONT.AFS | 63 mmø | 2.50871 | 6.3 | IF.FONT.AFS 5
3701170 | 953.892 | -35.28 | Piping System: IF.FONT.AFS | 63 mmø | 1.88795 | 6.3 | IF.FONT.AFS 5
3701179 | 205.8 | -35.28 | Piping System: IF.FONT.AFS | 63 mmø | 0.40732 | 6.3 | IF.FONT.AFS 5
3701192 | 61.2296 | -35.28 | Piping System: IF.FONT.AFS | 63 mmø | 0.121186 | 6.3 | IF.FONT.AFS 5
3701537 | 58.0636 | -35.28 | Piping System: IF.FONT.AFS | 63 mmø | 0.11492 | 6.3 | IF.FONT.AFS 5
3701557 | 35.9433 | -35.28 | Piping System: IF.FONT.AFS | 63 mmø | 0.0711392 | 6.3 | IF.FONT.AFS 5
3703502 | 40.3493 | -35.28 | Piping System: IF.FONT.AFS | 63 mmø | 0.0798595 | 6.3 | IF.FONT.AFS 5

# IfcFlowSegment: Pipe Types:AMB.PCIAcerCarbon_EN 10255_Series M (29)
Type - Pset_ProductRequirements - Category: Pipes
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.50.10.70; 105.AMB.ClassificacioDescripcio: BIES; 109.AMB.CodiTipus: PCI14; 111.AMB.DescripcioTipus: Tub de Acer segons EN 10255
Classification: 50.50.10.70 BIES (Uniformat); Group: IF.EXTI.BIEs 5
Pset_DistributionFlowElementCommon - Reference: Pipe Types:AMB.PCIAcerCarbon_EN 10255_Series M; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.000254 cm
1 AMB.Identificacio - 107.AMB.NomTipus: Pipe Types: AMB.PCIAcerCarbon_EN 10255_Series M; 112.AMB.Servei: Piping System: IF.EXTI.BIEs; 119.AMB.FaseCreacio: Obra
Name (Pipe Types:AMB.PCIAcerCarbon_EN 10255_Series M:...) | In | Pset_FlowSegmentDuctSegment, Length (cm) = Pset_FlowSegmentPipeSegment, Length (cm) = 501.AMB.Longitud (cm) | InvertElevation (cm) | 115.AMB.Nivell | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (cm)
3396681 | P0 | 125.493 | 285.745 | Level: P0 | 50 mmø | 0.197124 | 5
3396760 | P0 | 6.50296 | 285.7 | Level: P0 | 32 mmø | 0.00653749 | 3.2
3401217 | P0 | 169.9 | 292.3 | Level: P0 | 32 mmø | 0.170802 | 3.2
3401282 | P0 | 1.21504 | 285.7 | Level: P0 | 32 mmø | 0.00122149 | 3.2
3402471 | P0 | 13.5498 | 133.4 | Level: P0 | 32 mmø | 0.0136218 | 3.2
3402502 | P1 | 149.3 | 133.4 | Level: P1 | 32 mmø | 0.150093 | 3.2
3402610 | P1 | 55.2801 | 126.8 | Level: P1 | 32 mmø | 0.0555736 | 3.2
3402728 | P0 | 115.773 | 285.405 | Level: P0 | 40 mmø | 0.145485 | 4
3402839 | P1 | 25.1498 | 471.8 | Level: P1 | 32 mmø | 0.0252834 | 3.2
3402856 | P1 | 25.1498 | 471.8 | Level: P1 | 32 mmø | 0.0252834 | 3.2
3402873 | P0 | 25.1498 | 121.8 | Level: P0 | 32 mmø | 0.0252834 | 3.2
3402900 | P1 | 72.4966 | 465.2 | Level: P1 | 32 mmø | 0.0728815 | 3.2
3402908 | P1 | 12.5854 | 465.2 | Level: P1 | 32 mmø | 0.0126522 | 3.2
3403041 | P0 | 29.0456 | 115.2 | Level: P0 | 32 mmø | 0.0291999 | 3.2
3403081 | P0 | 130.4 | 121.8 | Level: P0 | 32 mmø | 0.131092 | 3.2
3403110 | P1 | 28.8424 | 465.2 | Level: P1 | 32 mmø | 0.0289956 | 3.2
3403311 | P0 | 2355.2 | 285.405 | Level: P0 | 40 mmø | 2.95963 | 4
3403376 | P0 | 162.6 | 299.6 | Level: P0 | 32 mmø | 0.163463 | 3.2
3403444 | P0 | 19.1569 | 255.2 | Level: P0 | 32 mmø | 0.0192586 | 3.2
3403490 | P1 | 16.3701 | 465.2 | Level: P1 | 32 mmø | 0.016457 | 3.2
3403582 | P0 | 6.39769 | 285.405 | Level: P0 | 40 mmø | 0.00803957 | 4
3403607 | P0 | 53.6535 | -34.755 | Level: P0 | 50 mmø | 0.0842787 | 5
3403636 | P0 | 50.2196 | 285.745 | Level: P0 | 50 mmø | 0.0788848 | 5
3403663 | P0 | 305.3 | -25.4 | Level: P0 | 50 mmø | 0.479564 | 5
3563011 | P0 | 9.42531 | -34.755 | Level: P0 | 50 mmø | 0.0148052 | 5
3783662 | P0 | 176.268 | 285.405 | Level: P0 | 40 mmø | 0.221505 | 4
3783670 | P0 | 175.583 | 285.405 | Level: P0 | 40 mmø | 0.220644 | 4
3783681 | P0 | 199.412 | 285.405 | Level: P0 | 40 mmø | 0.250589 | 4
3783786 | P0 | 13.6 | 261.8 | Level: P0 | 32 mmø | 0.0136722 | 3.2

# IfcFlowSegment: Pipe Types:AMB.PVC.Soterrat.EN 1329-1_Series B (63)
Type - Pset_ProductRequirements - Category: Pipes
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals; 109.AMB.CodiTipus: SAN16; 111.AMB.DescripcioTipus: Tub de PVC segons EN 1329-1 B
Classification: 50.20.20.20 Canalitzacions d'aigües residuals (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:AMB.PVC.Soterrat.EN 1329-1_Series B; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.000254 cm
1 AMB.Identificacio - 107.AMB.NomTipus: Pipe Types: AMB.PVC.Soterrat.EN 1329-1_Series B; 119.AMB.FaseCreacio: Obra
Name (Pipe Types:AMB.PVC.Soterrat.EN 1329-1_Series B:...) | In | Pset_FlowSegmentDuctSegment, Length (cm) = Pset_FlowSegmentPipeSegment, Length (cm) = 501.AMB.Longitud (cm) | InvertElevation (cm) | 112.AMB.Servei | 115.AMB.Nivell | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (cm) | Group
3534508 | P0 | 265.601 | -18.9292 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 1.04301 | 12.5 | IF.SANE.Pluvial 6
3534517 | P0 | 526.084 | -30.4486 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 2.06593 | 12.5 | IF.SANE.Pluvial 6
3534541 | P0 | 124.489 | -49.3224 | Piping System: IF.SANE.Pluvial | Level: P0 | 160 mmø | 0.625751 | 16 | IF.SANE.Pluvial 6
3535697 | P0 | 151.587 | -52.5535 | Piping System: IF.SANE.Pluvial | Level: P0 | 160 mmø | 0.761958 | 16 | IF.SANE.Pluvial 6
3535777 | P0 | 8.31438 | -44.3567 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 0.0326505 | 12.5 | IF.SANE.Pluvial 6
3535786 | P0 | 647.59 | -46.3353 | Piping System: IF.SANE.Pluvial | Level: P0 | 160 mmø | 3.25514 | 16 | IF.SANE.Pluvial 6
3535792 | P0 | 64.6908 | -44.0447 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 0.25404 | 12.5 | IF.SANE.Pluvial 6
3536924 | P0 | 142.393 | -48.7819 | Piping System: IF.SANE.Pluvial | Level: P0 | 160 mmø | 0.715744 | 16 | IF.SANE.Pluvial 11
3536933 | P0 | 707.83 | -38.1634 | Piping System: IF.SANE.Pluvial | Level: P0 | 160 mmø | 3.55794 | 16 | IF.SANE.Pluvial 11
3536949 | P0 | 153.629 | -23.8097 | Piping System: IF.SANE.Pluvial | Level: P0 | 160 mmø | 0.772224 | 16 | IF.SANE.Pluvial 11
3537043 | P0 | 294.482 | -45.7067 | Piping System: IF.SANE.Pluvial | Level: P0 | 160 mmø | 1.48023 | 16 | IF.SANE.Pluvial 11
3537077 | P0 | 35.1631 | -37.0769 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 0.138085 | 12.5 | IF.SANE.Pluvial 11
3537085 | P0 | 10.5244 | -35.374 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 0.0413291 | 12.5 | IF.SANE.Pluvial 11
3537375 | P0 | 12.2354 | -32.5832 | Piping System: IF.SANE.Pluvial | Level: P0 | 160 mmø | 0.0615019 | 16 | IF.SANE.Pluvial 6
3537387 | P0 | 36.6858 | -31.0588 | Piping System: IF.SANE.Pluvial | Level: P0 | 160 mmø | 0.184403 | 16 | IF.SANE.Pluvial 6
3538118 | P0 | 34.7869 | -35.7797 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 0.136608 | 12.5 | IF.SANE.Pluvial 11
3538129 | P0 | 47.4091 | -39.2707 | Piping System: IF.SANE.Pluvial | Level: P0 | 160 mmø | 0.238304 | 16 | IF.SANE.Pluvial 11
3538140 | P0 | 21.6267 | -34.1286 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 0.0849278 | 12.5 | IF.SANE.Pluvial 11
3538251 | P0 | 87.3668 | -72.0653 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 0.343089 | 12.5 | IF.SANE.Pluvial 5
3538275 | P0 | 355.644 | -68.9573 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 1.39661 | 12.5 | IF.SANE.Pluvial 5
3539387 | P0 | 14.6509 | -73.0102 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 0.057534 | 12.5 | IF.SANE.Pluvial 5
3539396 | P0 | 1096.59 | -76.2459 | Piping System: IF.SANE.Pluvial | Level: P0 | 160 mmø | 5.51207 | 16 | IF.SANE.Pluvial 5
3539889 | P0 | 279.576 | -65.6156 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 1.09789 | 12.5 | IF.SANE.Pluvial 5
3539895 | P0 | 67.1459 | -59.0254 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 0.263681 | 12.5 | IF.SANE.Pluvial 5
3540262 | P0 | 769.983 | -74.0537 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 3.02372 | 12.5 | IF.SANE.Pluvial 5
3540271 | P0 | 54.6602 | -76.2459 | Piping System: IF.SANE.Pluvial | Level: P0 | 160 mmø | 0.274752 | 16 | IF.SANE.Pluvial 5
3540437 | P0 | 515 | -39.5639 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 2.0224 | 12.5 | IF.SANE.Pluvial 7
3540527 | P0 | 16.7972 | -4.79721 | Piping System: IF.SANE.Pluvial | Level: P0 | 90 mmø | 0.047493 | 9 | IF.SANE.Pluvial 7
3540657 | P0 | 931.17 | -85.1725 | Piping System: IF.SANE.Fecal | Level: P0 | 160 mmø | 4.68057 | 16 | IF.SANE.Fecal 1
3540666 | P0 | 415.895 | -65.2731 | Piping System: IF.SANE.Fecal | Level: P0 | 160 mmø | 2.09052 | 16 | IF.SANE.Fecal 1
3540677 | P0 | 126.607 | -55.6772 | Piping System: IF.SANE.Fecal | Level: P0 | 160 mmø | 0.636394 | 16 | IF.SANE.Fecal 1
3543533 | P0 | 947.556 | -101.625 | Piping System: IF.SANE.Pluvial | Level: P0 | 160 mmø | 4.76294 | 16 | IF.SANE.Pluvial 3
3543542 | P0 | 667.811 | -79.4022 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 2.62249 | 12.5 | IF.SANE.Pluvial 3
3543594 | P0 | 9.09327 | -80.2043 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 0.0357092 | 12.5 | IF.SANE.Pluvial 3
3543604 | P0 | 361.47 | -79.0226 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 1.41949 | 12.5 | IF.SANE.Pluvial 3
3543695 | P0 | 75.6572 | -71.6306 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 0.297105 | 12.5 | IF.SANE.Pluvial 3
3543972 | P0 | 6.19714 | -79.4024 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 0.0243361 | 12.5 | IF.SANE.Pluvial 3
3543981 | P0 | 20.6155 | -80.2043 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 0.0809567 | 12.5 | IF.SANE.Pluvial 3
3544157 | P0 | 81.9937 | -65.6155 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 0.321988 | 12.5 | IF.SANE.Pluvial 5
3544168 | P0 | 288.473 | -71.7177 | Piping System: IF.SANE.Pluvial | Level: P0 | 125 mmø | 1.13283 | 12.5 | IF.SANE.Pluvial 5
3770865 | P0 | 1637.53 | -110.119 | Piping System: IF.SANE.Fecal | Level: P0 | 125 mmø | 6.43058 | 12.5 | IF.SANE.Fecal 4
3770867 | P0 | 91.7143 | -76.3747 | Piping System: IF.SANE.Fecal | Level: P0 | 125 mmø | 0.360161 | 12.5 | IF.SANE.Fecal 4
3770871 | P0 | 69.8088 | -64.352 | Piping System: IF.SANE.Fecal | Level: P0 | 110 mmø | 0.241242 | 11 | IF.SANE.Fecal 4
3770875 | P0 | 21.8923 | -68.4592 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø | 0.0343883 | 5 | IF.SANE.Fecal 4
3770878 | P0 | 13.9701 | -72.9464 | Piping System: IF.SANE.Fecal | Level: P0 | 125 mmø | 0.0548604 | 12.5 | IF.SANE.Fecal 4
3770883 | P0 | 7.36754 | -66.208 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø | 0.0115729 | 5 | IF.SANE.Fecal 4
3770886 | P0 | 31.2726 | -71.1493 | Piping System: IF.SANE.Fecal | Level: P0 | 125 mmø | 0.122807 | 12.5 | IF.SANE.Fecal 4
3770892 | P0 | 37.4087 | -72.3651 | Piping System: IF.SANE.Fecal | Level: P0 | 125 mmø | 0.146904 | 12.5 | IF.SANE.Fecal 4
3770897 | P0 | 4.84687 | -67.3315 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø | 0.00761344 | 5 | IF.SANE.Fecal 4
3770899 | P0 | 20.1489 | -66.8934 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø | 0.0316498 | 5 | IF.SANE.Fecal 4
3770903 | P0 | 71.7727 | -54.7727 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø | 0.11274 | 5 | IF.SANE.Fecal 4
3770905 | P0 | 15.6536 | -69.5252 | Piping System: IF.SANE.Fecal | Level: P0 | 125 mmø | 0.0614715 | 12.5 | IF.SANE.Fecal 4
3770911 | P0 | 21.2671 | -65.7961 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø | 0.0334062 | 5 | IF.SANE.Fecal 4
3770914 | P0 | 17.927 | -70.2235 | Piping System: IF.SANE.Fecal | Level: P0 | 125 mmø | 0.0703992 | 12.5 | IF.SANE.Fecal 4
3770921 | P1 | 131.561 | 305.818 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø | 0.206656 | 5 | IF.SANE.Fecal 4
3770929 | P0 | 130.122 | -55.6219 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø | 0.204395 | 5 | IF.SANE.Fecal 4
3770933 | P0 | 128.591 | -54.0912 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø | 0.20199 | 5 | IF.SANE.Fecal 4
3770937 | P0 | 128.161 | -53.6611 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø | 0.201315 | 5 | IF.SANE.Fecal 4
3770943 | P0 | 78.8367 | -61.0267 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø | 0.123836 | 5 | IF.SANE.Fecal 4
3770946 | P0 | 173.335 | -68.1664 | Piping System: IF.SANE.Fecal | Level: P0 | 110 mmø | 0.599003 | 11 | IF.SANE.Fecal 4
3770951 | P0 | 55.8281 | -59.3802 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø | 0.0876946 | 5 | IF.SANE.Fecal 4
3770955 | P0 | 94.7236 | -68.9843 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø | 0.148791 | 5 | IF.SANE.Fecal 4
3770958 | P0 | 15.2334 | -73.541 | Piping System: IF.SANE.Fecal | Level: P0 | 125 mmø | 0.0598213 | 12.5 | IF.SANE.Fecal 4

# IfcFlowSegment: Pipe Types:AMB.SAN.Plàstic.PVC (84)
Type - Pset_ProductRequirements - Category: Pipes
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals; 109.AMB.CodiTipus: SAN19; 111.AMB.DescripcioTipus: Tuberia PVC
Classification: 50.20.20.20 Canalitzacions d'aigües residuals (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:AMB.SAN.Plàstic.PVC; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.000254 cm
1 AMB.Identificacio - 107.AMB.NomTipus: Pipe Types: AMB.SAN.Plàstic.PVC; 119.AMB.FaseCreacio: Obra
Name (Pipe Types:AMB.SAN.Plàstic.PVC:...) | In | Pset_FlowSegmentDuctSegment, Length (cm) = Pset_FlowSegmentPipeSegment, Length (cm) = 501.AMB.Longitud (cm) | InvertElevation (cm) | 112.AMB.Servei | 115.AMB.Nivell | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (cm) | Group
3309852 | P2 | 791.076 | -45.5756 | Piping System: IF.SANE.Pluvial | Level: P2 | 90 mmø | 2.23671 | 9 | IF.SANE.Pluvial 3
3309889 | P2 | 800.313 | -54.8131 | Piping System: IF.SANE.Pluvial | Level: P2 | 90 mmø | 2.26283 | 9 | IF.SANE.Pluvial 3
3309927 | P2 | 7.43777 | -75.9963 | Piping System: IF.SANE.Fecal | Level: P2 | 110 mmø | 0.0257031 | 11 | IF.SANE.Fecal 7
3310015 | P2 | 779.62 | -34.1204 | Piping System: IF.SANE.Pluvial | Level: P2 | 90 mmø | 2.20432 | 9 | IF.SANE.Pluvial 5
3310174 | P2 | 739.986 | 5.6206 | Piping System: IF.SANE.Pluvial | Level: P2 | 90 mmø | 2.09226 | 9 | IF.SANE.Pluvial 11
3351438 | P2 | 784.796 | -39.296 | Piping System: IF.SANE.Pluvial | Level: P2 | 90 mmø | 2.21896 | 9 | IF.SANE.Pluvial 5
3351461 | P2 | 782.807 | -37.3072 | Piping System: IF.SANE.Pluvial | Level: P2 | 90 mmø | 2.21334 | 9 | IF.SANE.Pluvial 5
3351530 | P2 | 778.644 | -33.1441 | Piping System: IF.SANE.Pluvial | Level: P2 | 90 mmø | 2.20156 | 9 | IF.SANE.Pluvial 5
3351546 | P2 | 787.01 | -41.51 | Piping System: IF.SANE.Pluvial | Level: P2 | 90 mmø | 2.22522 | 9 | IF.SANE.Pluvial 3
3351596 | P1 | 24.3895 | 341.611 | Piping System: IF.SANE.Fecal | Level: P1 | 110 mmø | 0.0842839 | 11 | IF.SANE.Fecal 7
3351731 | P0 | 43.8895 | -27.8895 | Piping System: IF.SANE.Fecal | Level: P0 | 110 mmø | 0.151671 | 11 | IF.SANE.Fecal 7
3351752 | P0 | 50.3388 | -34.3388 | Piping System: IF.SANE.Fecal | Level: P0 | 110 mmø | 0.173958 | 11 | IF.SANE.Fecal 7
3351774 | P0 | 24.3895 | -8.38945 | Piping System: IF.SANE.Fecal | Level: P0 | 110 mmø | 0.0842839 | 11 | IF.SANE.Fecal 7
3356141 | P1 | 10.4629 | 346.172 | Piping System: IF.SANE.Fecal | Level: P1 | 110 mmø | 0.0361572 | 11 | IF.SANE.Fecal 7
3356165 | P0 | 35.9629 | -29.3278 | Piping System: IF.SANE.Fecal | Level: P0 | 110 mmø | 0.124279 | 11 | IF.SANE.Fecal 7
3356263 | P0 | 1.39665 | 71.3 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø | 0.00219385 | 5 | IF.SANE.Fecal 3
3356290 | P1 | 29.4241 | -6.9051 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø | 0.0462193 | 5 | IF.SANE.Fecal 3
3356315 | P0 | 2.35606 | 71.3 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø | 0.00370089 | 5 | IF.SANE.Fecal 3
3356336 | P0 | 0.719401 | 71.3 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø | 0.00113003 | 5 | IF.SANE.Fecal 3
3356375 | P1 | 24.359 | 43.141 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø | 0.038263 | 5 | IF.SANE.Fecal 3
3356382 | P1 | 34.5421 | 32.9579 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø | 0.0542586 | 5 | IF.SANE.Fecal 3
3356396 | P1 | 1.91105 | 421.3 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø | 0.00300187 | 5 | IF.SANE.Fecal 7
3356417 | P1 | 0.450487 | 421.3 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø | 0.000707623 | 5 | IF.SANE.Fecal 7
3356439 | P1 | 0.589841 | 421.3 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø | 0.00092652 | 5 | IF.SANE.Fecal 7
3356460 | P1 | 0.852834 | 421.3 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø | 0.00133963 | 5 | IF.SANE.Fecal 3
3356474 | P1 | 24.4022 | 393.098 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø | 0.0383308 | 5 | IF.SANE.Fecal 7
3356481 | P1 | 56.7569 | 315.742 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø | 0.0891535 | 5 | IF.SANE.Fecal 7
3356488 | P1 | 34.6255 | 382.874 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø | 0.0543897 | 5 | IF.SANE.Fecal 7
3356495 | P1 | 117.599 | 299.901 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø | 0.184724 | 5 | IF.SANE.Fecal 3
3356772 | P1 | 80.8172 | 321.859 | Piping System: IF.SANE.Fecal | Level: P1 | 110 mmø | 0.279284 | 11 | IF.SANE.Fecal 7
3356847 | P1 | 42.6273 | 322.783 | Piping System: IF.SANE.Fecal | Level: P1 | 110 mmø | 0.147309 | 11 | IF.SANE.Fecal 7
3356859 | P1 | 15.6117 | 313.316 | Piping System: IF.SANE.Fecal | Level: P1 | 110 mmø | 0.0539501 | 11 | IF.SANE.Fecal 7
3357299 | P1 | 104.713 | 326.718 | Piping System: IF.SANE.Fecal | Level: P1 | 110 mmø | 0.361862 | 11 | IF.SANE.Fecal 7
3531809 | P1 | 36.0669 | 373.935 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø | 0.0566538 | 5 | IF.SANE.Fecal 7
3532350 | P1 | 35.7931 | 384.164 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø | 0.0562236 | 5 | IF.SANE.Fecal 7
3532656 | P1 | 3.23415 | 379.5 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø | 0.0050802 | 5 | IF.SANE.Fecal 7
3532664 | P1 | 27.7651 | 389.735 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø | 0.0436133 | 5 | IF.SANE.Fecal 7
3532784 | P1 | 171.708 | 304.089 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø | 0.269718 | 5 | IF.SANE.Fecal 7
3532950 | P2 | 7.70768 | 310.969 | Piping System: IF.SANE.Fecal | Level: P2 | 110 mmø | 0.0266358 | 11 | IF.SANE.Fecal 7
3533066 | P1 | 287.603 | 285.932 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø | 0.451766 | 5 | IF.SANE.Fecal 3
3533187 | P0 | 86.0077 | -48.2102 | Piping System: IF.SANE.Fecal | Level: P0 | 110 mmø | 0.297221 | 11 | IF.SANE.Fecal 7
3533189 | P0 | 2.45969 | -26.8152 | Piping System: IF.SANE.Fecal | Level: P0 | 110 mmø | 0.00850006 | 11 | IF.SANE.Fecal 7
3533191 | P0 | 68.2326 | -61.994 | Piping System: IF.SANE.Fecal | Level: P0 | 110 mmø | 0.235795 | 11 | IF.SANE.Fecal 7
3533193 | P0 | 110.047 | -48.8358 | Piping System: IF.SANE.Fecal | Level: P0 | 110 mmø | 0.380296 | 11 | IF.SANE.Fecal 7
3533195 | P0 | 44.9272 | 23.841 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø | 0.0705715 | 5 | IF.SANE.Fecal 3
3533197 | P0 | 43.2615 | 34.0574 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø | 0.0679549 | 5 | IF.SANE.Fecal 3
3533240 | P0 | 90.5624 | -47.1962 | Piping System: IF.SANE.Fecal | Level: P0 | 110 mmø | 0.312961 | 11 | IF.SANE.Fecal 7
3533251 | P2 | 0.797418 | -51.5508 | Piping System: IF.SANE.Fecal | Level: P2 | 110 mmø | 0.00275568 | 11 | IF.SANE.Fecal 7
3533298 | P1 | 3.21542 | 29.52 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø | 0.00505077 | 5 | IF.SANE.Fecal 3
3533333 | P1 | 27.7636 | 39.7364 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø | 0.0436109 | 5 | IF.SANE.Fecal 3
3533348 | P2 | 29.2734 | -80.6524 | Piping System: IF.SANE.Fecal | Level: P2 | 110 mmø | 0.101162 | 11 | IF.SANE.Fecal 7
3533360 | P2 | 337.546 | -35.9784 | Piping System: IF.SANE.Fecal | Level: P2 | 110 mmø | 1.16648 | 11 | IF.SANE.Fecal 7
3533419 | P0 | 1.72394 | 71.0367 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø | 0.00270796 | 5 | IF.SANE.Fecal 15
3533484 | P1 | 97.7015 | -30.4798 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø | 0.153469 | 5 | IF.SANE.Fecal 15
3533827 | P2 | 372.853 | -35.3528 | Piping System: IF.SANE.Fecal | Level: P2 | 110 mmø | 1.28849 | 11 | IF.SANE.Fecal 7
3534029 | P2 | 734.58 | 10.9204 | Piping System: IF.SANE.Pluvial | Level: P2 | 90 mmø | 2.07697 | 9 | IF.SANE.Pluvial 6
3534059 | P2 | 749.467 | -3.96687 | Piping System: IF.SANE.Pluvial | Level: P2 | 90 mmø | 2.11907 | 9 | IF.SANE.Pluvial 6
3534089 | P2 | 763.712 | -18.2124 | Piping System: IF.SANE.Pluvial | Level: P2 | 90 mmø | 2.15935 | 9 | IF.SANE.Pluvial 6
3534111 | P2 | 756.125 | -10.6249 | Piping System: IF.SANE.Pluvial | Level: P2 | 90 mmø | 2.13789 | 9 | IF.SANE.Pluvial 11
3534113 | P2 | 762.253 | -16.7531 | Piping System: IF.SANE.Pluvial | Level: P2 | 90 mmø | 2.15522 | 9 | IF.SANE.Pluvial 11
3540800 | P0 | 325.589 | -45.2089 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø | 0.511434 | 5 | IF.SANE.Fecal 15
3540921 | P0 | 226.099 | -19.6447 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø | 0.355155 | 5 | IF.SANE.Fecal 3
3543216 | P0 | 279.309 | -101.002 | Piping System: IF.SANE.Fecal | Level: P0 | 125 mmø | 1.09684 | 12.5 | IF.SANE.Fecal 7
3543305 | P0 | 69.2608 | -100.251 | Piping System: IF.SANE.Fecal | Level: P0 | 110 mmø | 0.239348 | 11 | IF.SANE.Fecal 7
3543319 | P0 | 116 | -103.697 | Piping System: IF.SANE.Fecal | Level: P0 | 125 mmø | 0.455531 | 12.5 | IF.SANE.Fecal 7
3637201 | P0 | 510.757 | 296.5 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø | 0.320918 | 2 | IF.SANE.Fecal 2
3637304 | P0 | 511.197 | 296.5 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø | 0.321194 | 2 | IF.SANE.Fecal 2
3637315 | P0 | 511.197 | 296.5 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø | 0.321194 | 2 | IF.SANE.Fecal 2
3637326 | P0 | 511.197 | 296.5 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø | 0.321194 | 2 | IF.SANE.Fecal 2
3637455 | P0 | 367.069 | 296.5 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø | 0.230636 | 2 | IF.SANE.Fecal 2
3637464 | P0 | 517.293 | 296.5 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø | 0.325025 | 2 | IF.SANE.Fecal 2
3637475 | P0 | 205.619 | 296.5 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø | 0.129194 | 2 | IF.SANE.Fecal 2
3637535 | P0 | 137.248 | 296.5 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø | 0.0862352 | 2 | IF.SANE.Fecal 2
3684945 | P0 | 516.784 | 296.5 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø | 0.324705 | 2 | IF.SANE.Fecal 2
3686048 | P1 | 170.06 | 124 | Piping System: IF.SANE.Fecal | Level: P1 | 20 mmø | 0.106852 | 2 | IF.SANE.Fecal 2
3690970 | P0 | 211.06 | 83 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø | 0.132613 | 2 | IF.SANE.Fecal 2
3691231 | P0 | 212.56 | 81.5 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø | 0.133555 | 2 | IF.SANE.Fecal 2
3691267 | P0 | 212.56 | 81.5 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø | 0.133555 | 2 | IF.SANE.Fecal 2
3691386 | P0 | 212.56 | 81.5 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø | 0.133555 | 2 | IF.SANE.Fecal 2
3691502 | P0 | 212.56 | 81.5 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø | 0.133555 | 2 | IF.SANE.Fecal 2
3772388 | P1 | 90.5824 | 322.822 | Piping System: IF.SANE.Fecal | Level: P1 | 110 mmø | 0.31303 | 11
3776202 | P0 | 284.148 | 296.5 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø | 0.178535 | 2 | IF.SANE.Fecal 2
3776276 | P0 | 32.3353 | 296.5 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø | 0.0203169 | 2 | IF.SANE.Fecal 2
3776319 | P0 | 350.28 | 296.5 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø | 0.220087 | 2 | IF.SANE.Fecal 2

# IfcFlowSegment: Pipe Types:AMB_Plàstic.PVC (5)
Type - Pset_ProductRequirements - Category: Pipes
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals
Classification: 50.20.20.20 Canalitzacions d'aigües residuals (Uniformat); Group: IF.SANE.Fecal 4
Pset_DistributionFlowElementCommon - Reference: Pipe Types:AMB_Plàstic.PVC; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.000254 cm
1 AMB.Identificacio - 107.AMB.NomTipus: Pipe Types: AMB_Plàstic.PVC; 112.AMB.Servei: Piping System: IF.SANE.Fecal; 119.AMB.FaseCreacio: Obra
Name (Pipe Types:AMB_Plàstic.PVC:...) | In | Pset_FlowSegmentDuctSegment, Length (cm) = Pset_FlowSegmentPipeSegment, Length (cm) = 501.AMB.Longitud (cm) | InvertElevation (cm) | 115.AMB.Nivell | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (cm)
3770853 | P0 | 38.1507 | 320.849 | Level: P0 | 50 mmø | 0.0599269 | 5
3770858 | P0 | 51.3373 | -35.3373 | Level: P0 | 110 mmø | 0.177409 | 11
3770860 | P0 | 7.89232 | 71.3 | Level: P0 | 50 mmø | 0.0123972 | 5
3770862 | P1 | 113.367 | -45.867 | Level: P1 | 50 mmø | 0.178076 | 5
3770909 | P1 | 359.271 | -57.2719 | Level: P1 | 50 mmø | 0.564341 | 5

# IfcFlowSegment: Rectangular Duct:AMB.CLI.ConducteRectangular.AportacióPrimari (56)
Type - Pset_ElementShading - Roughness: 0.009144 cm
Type - Pset_ProductRequirements - Category: Ducts
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.10; 105.AMB.ClassificacioDescripcio: Aportació de aire primari; 109.AMB.CodiTipus: CLI17; 111.AMB.DescripcioTipus: Conducte rectangular. Aportació primari
Classification: 50.30.40.10 Aportació de aire primari (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Rectangular Duct:AMB.CLI.ConducteRectangular.AportacióPrimari; sets with these values: 2
Pset_DuctSegmentTypeCommon - sets with these values: 3
1 AMB.Identificacio - 107.AMB.NomTipus: Rectangular Duct: AMB.CLI.ConducteRectangular.AportacióPrimari; 112.AMB.Servei: Duct System: IC.AIRE.Aportació; 119.AMB.FaseCreacio: Obra
Name (Rectangular Duct:AMB.CLI.ConducteRectangular.AportacióPrimari:...) | In | Length (cm) = 501.AMB.Longitud (cm) | 115.AMB.Nivell | 242.AMB.Mida | 502.AMB.Amplada (cm) | 503.AMB.Altura (cm) | 507.AMB.Area (m2) | Group
3446550 | P0 | 459.545 | Level: P0 | 250 mmx250 mm | 25 | 25 | 4.59545 | Mechanical IC.AIRE.Aportació 5
3446585 | P0 | 275.113 | Level: P0 | 250 mmx250 mm | 25 | 25 | 2.75113 | Mechanical IC.AIRE.Aportació 5
3446708 | P0 | 419.381 | Level: P0 | 650 mmx250 mm | 65 | 25 | 7.54885 | Mechanical IC.AIRE.Aportació 5
3446758 | P0 | 6.72775 | Level: P0 | 650 mmx250 mm | 65 | 25 | 0.1211 | Mechanical IC.AIRE.Aportació 5
3446808 | P0 | 14.7278 | Level: P0 | 500 mmx250 mm | 50 | 25 | 0.220916 | Mechanical IC.AIRE.Aportació 5
3447117 | P0 | 114 | Level: P0 | 450 mmx250 mm | 45 | 25 | 1.596 | Mechanical IC.AIRE.Aportació 5
3447241 | P0 | 18.6412 | Level: P0 | 250 mmx150 mm | 25 | 15 | 0.14913 | Mechanical IC.AIRE.Aportació 5
3447257 | P0 | 276.535 | Level: P0 | 500 mmx250 mm | 50 | 25 | 4.14802 | Mechanical IC.AIRE.Aportació 5
3447331 | P0 | 67.8921 | Level: P0 | 350 mmx300 mm | 35 | 30 | 0.882598 | Mechanical IC.AIRE.Aportació 5
3447515 | P0 | 27.5477 | Level: P0 | 350 mmx300 mm | 35 | 30 | 0.35812 | Mechanical IC.AIRE.Aportació 5
3447527 | P0 | 411.514 | Level: P0 | 250 mmx250 mm | 25 | 25 | 4.11514 | Mechanical IC.AIRE.Aportació 5
3447579 | P0 | 3.10703 | Level: P0 | 350 mmx300 mm | 35 | 30 | 0.0403914 | Mechanical IC.AIRE.Aportació 5
3447730 | P0 | 21.2872 | Level: P0 | 400 mmx250 mm | 40 | 25 | 0.276734 | Mechanical IC.AIRE.Aportació 5
3448377 | P0 | 20 | Level: P0 | 250 mmx150 mm | 25 | 15 | 0.16 | Mechanical IC.AIRE.Aportació 5
3448387 | P0 | 381.868 | Level: P0 | 250 mmx250 mm | 25 | 25 | 3.81868 | Mechanical IC.AIRE.Aportació 5
3448466 | P0 | 7.15331 | Level: P0 | 400 mmx150 mm | 40 | 15 | 0.0786864 | Mechanical IC.AIRE.Aportació 5
3455166 | P0 | 0.580084 | Level: P0 | 900 mmx250 mm | 90 | 25 | 0.0133419 | Mechanical IC.AIRE.Aportació 4
3456052 | P0 | 3.64048 | Level: P0 | 315 mmx315 mm | 31.5 | 31.5 | 0.04587 | Mechanical IC.AIRE.Aportació 4
3456107 | P0 | 2.46847 | Level: P0 | 315 mmx315 mm | 31.5 | 31.5 | 0.0311028 | Mechanical IC.AIRE.Aportació 5
3463740 | P0 | 195.992 | Level: P0 | 900 mmx250 mm | 90 | 25 | 4.50783 | Mechanical IC.AIRE.Aportació 4
3464082 | P0 | 11.9171 | Level: P0 | 400 mmx150 mm | 40 | 15 | 0.131088 | Mechanical IC.AIRE.Aportació 5
3464096 | P0 | 34.7362 | Level: P0 | 1000 mmx150 mm | 100 | 15 | 0.798933 | Mechanical IC.AIRE.Aportació 5
3464201 | P0 | 149.301 | Level: P0 | 650 mmx250 mm | 65 | 25 | 2.68741 | Mechanical IC.AIRE.Aportació 5
3471512 | P0 | 5 | Level: P0 | 250 mmx150 mm | 25 | 15 | 0.04 | Mechanical IC.AIRE.Aportació 5
3471528 | P0 | 55.9698 | Level: P0 | 400 mmx250 mm | 40 | 25 | 0.727607 | Mechanical IC.AIRE.Aportació 5
3697055 | P1 | 2.90331 | Level: P1 | 275 mmx150 mm | 27.5 | 15 | 0.0246782 | Mechanical IC.AIRE.Aportació 3
3697059 | P1 | 7.73382 | Level: P1 | 900 mmx250 mm | 90 | 25 | 0.177878 | Mechanical IC.AIRE.Aportació 2
3697061 | P1 | 1.00069 | Level: P1 | 315 mmx315 mm | 31.5 | 31.5 | 0.0126087 | Mechanical IC.AIRE.Aportació 2
3697063 | P1 | 9.57441 | Level: P1 | 315 mmx315 mm | 31.5 | 31.5 | 0.120638 | Mechanical IC.AIRE.Aportació 3
3697075 | P1 | 186.235 | Level: P1 | 900 mmx250 mm | 90 | 25 | 4.28341 | Mechanical IC.AIRE.Aportació 2
3697076 | P1 | 25.4992 | Level: P1 | 400 mmx150 mm | 40 | 15 | 0.280491 | Mechanical IC.AIRE.Aportació 3
3697078 | P1 | 0.692761 | Level: P1 | 1000 mmx150 mm | 100 | 15 | 0.0159335 | Mechanical IC.AIRE.Aportació 3
3697082 | P1 | 120.5 | Level: P1 | 550 mmx300 mm | 55 | 30 | 2.0485 | Mechanical IC.AIRE.Aportació 3
3697987 | P1 | 28.2689 | Level: P1 | 500 mmx250 mm | 50 | 25 | 0.424034 | Mechanical IC.AIRE.Aportació 3
3698009 | P1 | 103.792 | Level: P1 | 500 mmx250 mm | 50 | 25 | 1.55688 | Mechanical IC.AIRE.Aportació 3
3698073 | P1 | 1.02988 | Level: P1 | 400 mmx150 mm | 40 | 15 | 0.0113287 | Mechanical IC.AIRE.Aportació 3
3698196 | P1 | 714.256 | Level: P1 | 400 mmx250 mm | 40 | 25 | 9.28533 | Mechanical IC.AIRE.Aportació 3
3698207 | P1 | 111.706 | Level: P1 | 400 mmx250 mm | 40 | 25 | 1.45218 | Mechanical IC.AIRE.Aportació 3
3698638 | P1 | 7.64571 | Level: P1 | 400 mmx150 mm | 40 | 15 | 0.0841028 | Mechanical IC.AIRE.Aportació 3
3698660 | P1 | 36.4968 | Level: P1 | 400 mmx250 mm | 40 | 25 | 0.474458 | Mechanical IC.AIRE.Aportació 3
3699001 | P1 | 143.26 | Level: P1 | 250 mmx250 mm | 25 | 25 | 1.4326 | Mechanical IC.AIRE.Aportació 3
3699015 | P1 | 70.3263 | Level: P1 | 400 mmx250 mm | 40 | 25 | 0.914242 | Mechanical IC.AIRE.Aportació 3
3699045 | P1 | 258.264 | Level: P1 | 200 mmx200 mm | 20 | 20 | 2.06611 | Mechanical IC.AIRE.Aportació 3
3777674 | P1 | 2.1424 | Level: P1 | 1000 mmx150 mm | 100 | 15 | 0.0492752 | Mechanical IC.AIRE.Aportació 3
3777706 | P1 | 548.85 | Level: P1 | 400 mmx250 mm | 40 | 25 | 7.13505 | Mechanical IC.AIRE.Aportació 3
3778720 | P1 | 7.65795 | Level: P1 | 500 mmx250 mm | 50 | 25 | 0.114869 | Mechanical IC.AIRE.Aportació 3
3778764 | P1 | 0.673113 | Level: P1 | 1000 mmx150 mm | 100 | 15 | 0.0154816 | Mechanical IC.AIRE.Aportació 3
3779102 | P1 | 225.987 | Level: P1 | 500 mmx250 mm | 50 | 25 | 3.3898 | Mechanical IC.AIRE.Aportació 3
3782589 | P1 | 5.25 | Level: P1 | 400 mmx250 mm | 40 | 25 | 0.06825 | Mechanical IC.AIRE.Aportació 3
3782818 | P1 | 199.549 | Level: P1 | 400 mmx250 mm | 40 | 25 | 2.59414 | Mechanical IC.AIRE.Aportació 3
3782893 | S1 | 8.75 | Level: S1 | 400 mmx250 mm | 40 | 25 | 0.11375 | Mechanical IC.AIRE.Aportació 5
3782987 | P0 | 80.1121 | Level: P0 | 350 mmx300 mm | 35 | 30 | 1.04146 | Mechanical IC.AIRE.Aportació 5
3783081 | P0 | 11.2692 | Level: P0 | 400 mmx250 mm | 40 | 25 | 0.1465 | Mechanical IC.AIRE.Aportació 5
3783095 | P0 | 11.2692 | Level: P0 | 400 mmx250 mm | 40 | 25 | 0.1465 | Mechanical IC.AIRE.Aportació 5
3783156 | P0 | 102.835 | Level: P0 | 650 mmx250 mm | 65 | 25 | 1.85102 | Mechanical IC.AIRE.Aportació 5
3783173 | P0 | 31.7373 | Level: P0 | 500 mmx250 mm | 50 | 25 | 0.476059 | Mechanical IC.AIRE.Aportació 5

# IfcFlowSegment: Rectangular Duct:AMB.CLI.ConducteRectangular.ExtraccióPrimari (10)
Type - Pset_ElementShading - Roughness: 0.009144 cm
Type - Pset_ProductRequirements - Category: Ducts
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.20; 105.AMB.ClassificacioDescripcio: Extracció de aire primari; 109.AMB.CodiTipus: CLI20; 111.AMB.DescripcioTipus: Conducte rectangular. Extracció primari
Classification: 50.30.40.20 Extracció de aire primari (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Rectangular Duct:AMB.CLI.ConducteRectangular.ExtraccióPrimari; sets with these values: 2
Pset_DuctSegmentTypeCommon - sets with these values: 3
1 AMB.Identificacio - 107.AMB.NomTipus: Rectangular Duct: AMB.CLI.ConducteRectangular.ExtraccióPrimari; 112.AMB.Servei: Duct System: IC.AIRE.ExtraccióPrimari; 119.AMB.FaseCreacio: Obra
Name (Rectangular Duct:AMB.CLI.ConducteRectangular.ExtraccióPrimari:...) | In | Length (cm) = 501.AMB.Longitud (cm) | 115.AMB.Nivell | 242.AMB.Mida | 502.AMB.Amplada (cm) | 503.AMB.Altura (cm) | 507.AMB.Area (m2) | Group
3455248 | P0 | 135.986 | Level: P0 | 900 mmx250 mm | 90 | 25 | 3.12767 | Mechanical IC.AIRE.ExtraccióPrimari 3
3456142 | P0 | 2.46847 | Level: P0 | 315 mmx315 mm | 31.5 | 31.5 | 0.0311028 | Mechanical IC.AIRE.ExtraccióPrimari 2
3456174 | P0 | 30.2316 | Level: P0 | 315 mmx315 mm | 31.5 | 31.5 | 0.380918 | Mechanical IC.AIRE.ExtraccióPrimari 3
3463366 | P0 | 280 | Level: P0 | 900 mmx250 mm | 90 | 25 | 6.44 | Mechanical IC.AIRE.ExtraccióPrimari 2
3697060 | P1 | 183.267 | Level: P1 | 900 mmx250 mm | 90 | 25 | 4.21515 | Mechanical IC.AIRE.ExtraccióPrimari 4
3697065 | P1 | 9.57441 | Level: P1 | 315 mmx315 mm | 31.5 | 31.5 | 0.120638 | Mechanical IC.AIRE.ExtraccióPrimari 1
3697067 | P1 | 15.0644 | Level: P1 | 315 mmx315 mm | 31.5 | 31.5 | 0.189811 | Mechanical IC.AIRE.ExtraccióPrimari 4
3697074 | P1 | 248 | Level: P1 | 900 mmx250 mm | 90 | 25 | 5.704 | Mechanical IC.AIRE.ExtraccióPrimari 1
3781095 | P0 | 18.75 | Level: P0 | 900 mmx250 mm | 90 | 25 | 0.43125 | Mechanical IC.AIRE.ExtraccióPrimari 2
3781946 | P1 | 8.5 | Level: P1 | 900 mmx250 mm | 90 | 25 | 0.1955 | Mechanical IC.AIRE.ExtraccióPrimari 1

# IfcFlowSegment: Round Duct:AMB.CLI.ConducteCircular.Extracció (36)
Type - Pset_ElementShading - Roughness: 0.009144 cm
Type - Pset_ProductRequirements - Category: Ducts
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.50; 105.AMB.ClassificacioDescripcio: Extracció de fums; 109.AMB.CodiTipus: CLI51; 111.AMB.DescripcioTipus: Conducte circular xapa
Classification: 50.30.40.50 Extracció de fums (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Round Duct:AMB.CLI.ConducteCircular.Extracció; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: Round Duct: AMB.CLI.ConducteCircular.Extracció; 112.AMB.Servei: Duct System: IC.AIRE.Extracció.Serveis; 119.AMB.FaseCreacio: Obra
Name (Round Duct:AMB.CLI.ConducteCircular.Extracció:...) | In | Shape | Pset_DuctSegmentTypeCommon, Length (cm) = 501.AMB.Longitud (cm) | Pset_FlowSegmentDuctSegment, Length (cm) | Pset_FlowSegmentDuctSegment, sets with these values | 115.AMB.Nivell | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (cm) | Group
3480311 | P0 | Round | 143.361 | 143.361 | 2 | Level: P0 | 125 mmø | 0.562977 | 12.5 | Mechanical IC.AIRE.Extracció.Serveis 1
3480324 | P0 | Round | 648.908 | 648.908 | 2 | Level: P0 | 125 mmø | 2.54826 | 12.5 | Mechanical IC.AIRE.Extracció.Serveis 1
3480334 | P0 | Round | 93.6919 | 93.6919 | 2 | Level: P0 | 125 mmø | 0.367927 | 12.5 | Mechanical IC.AIRE.Extracció.Serveis 1
3480413 | P0 | Round | 447.75 | 447.75 | 2 | Level: P0 | 100 mmø | 1.40665 | 10 | Mechanical IC.AIRE.Extracció.Serveis 2
3480415 | P0 | Round | 108.567 | 108.567 | 2 | Level: P0 | 100 mmø | 0.341073 | 10 | Mechanical IC.AIRE.Extracció.Serveis 2
3480430 | P0 | Round | 445.987 | 445.987 | 2 | Level: P0 | 100 mmø | 1.40111 | 10 | Mechanical IC.AIRE.Extracció.Serveis 3
3480432 | P0 | Round | 125.353 | 125.353 | 2 | Level: P0 | 100 mmø | 0.393807 | 10 | Mechanical IC.AIRE.Extracció.Serveis 3
3480480 | P0 | Round | 387.233 | 387.233 | 2 | Level: P0 | 100 mmø | 1.21653 | 10 | Mechanical IC.AIRE.Extracció.Serveis 3
3480561 | P0 |  | 325.327 |  |  | Level: P0 | 100 mmø | 1.02204 | 10 | Mechanical IC.AIRE.Extracció.Serveis 4 | Pset_DuctSegmentTypeCommon - sets with these values: 3
3484047 | P0 | Round | 3.47999 | 3.47999 | 2 | Level: P0 | 160 mmø | 0.0174924 | 16 | Mechanical IC.AIRE.Extracció.Serveis 1
3484385 | P0 | Round | 404.019 | 404.019 | 2 | Level: P0 | 100 mmø | 1.26926 | 10 | Mechanical IC.AIRE.Extracció.Serveis 2
3484634 | P0 |  | 65.2881 |  |  | Level: P0 | 160 mmø | 0.328174 | 16 | Mechanical IC.AIRE.Extracció.Serveis 1 | Pset_DuctSegmentTypeCommon - sets with these values: 3
3484656 | P0 | Round | 3.25278 | 3.25278 | 2 | Level: P0 | 100 mmø | 0.0102189 | 10 | Mechanical IC.AIRE.Extracció.Serveis 3
3484671 | P0 | Round | 345.5 | 345.5 | 2 | Level: P0 | 100 mmø | 1.08542 | 10 | Mechanical IC.AIRE.Extracció.Serveis 3
3484702 | P0 | Round | 61 | 61 | 2 | Level: P0 | 100 mmø | 0.191637 | 10 | Mechanical IC.AIRE.Extracció.Serveis 2
3484760 | P0 | Round | 26.3084 | 26.3084 | 2 | Level: P0 | 100 mmø | 0.0826502 | 10 | Mechanical IC.AIRE.Extracció.Serveis 4
3484919 | P0 | Round | 31.4667 | 31.4667 | 2 | Level: P0 | 125 mmø | 0.12357 | 12.5 | Mechanical IC.AIRE.Extracció.Serveis 4
3484950 | P0 | Round | 127.987 | 127.987 | 2 | Level: P0 | 100 mmø | 0.402083 | 10 | Mechanical IC.AIRE.Extracció.Serveis 4
3611103 | P1 | Round | 264 | 264 | 2 | Level: P1 | 80 mmø | 0.663504 | 8 | Mechanical IC.AIRE.Extracció.Serveis 5
3657952 | P1 | Round | 237.566 | 237.566 | 2 | Level: P1 | 100 mmø | 0.746336 | 10 | Mechanical IC.AIRE.Extracció.Serveis 6
3657961 | P1 | Round | 178.6 | 178.6 | 2 | Level: P1 | 100 mmø | 0.561088 | 10 | Mechanical IC.AIRE.Extracció.Serveis 6
3657974 | P1 | Round | 19 | 19 | 2 | Level: P1 | 100 mmø | 0.0596903 | 10 | Mechanical IC.AIRE.Extracció.Serveis 6
3658127 | P1 | Round | 133.25 | 133.25 | 2 | Level: P1 | 100 mmø | 0.418617 | 10 | Mechanical IC.AIRE.Extracció.Serveis 6
3658140 | P1 | Round | 22 | 22 | 2 | Level: P1 | 100 mmø | 0.069115 | 10 | Mechanical IC.AIRE.Extracció.Serveis 6
3658458 | P1 | Round | 47.3594 | 47.3594 | 2 | Level: P1 | 100 mmø | 0.148784 | 10 | Mechanical IC.AIRE.Extracció.Serveis 6
3695403 | P1 | Round | 24.7828 | 24.7828 | 2 | Level: P1 | 150 mmø | 0.116786 | 15 | Mechanical IC.AIRE.Extracció.Serveis 9
3695442 | P1 | Round | 238.694 | 238.694 | 2 | Level: P1 | 100 mmø | 0.749881 | 10 | Mechanical IC.AIRE.Extracció.Serveis 9
3695512 | P1 | Round | 83 | 83 | 2 | Level: P1 | 125 mmø | 0.32594 | 12.5 | Mechanical IC.AIRE.Extracció.Serveis 9
3696601 | P1 |  | 148.717 |  |  | Level: P1 | 150 mmø | 0.700813 | 15 | Mechanical IC.AIRE.Extracció.Serveis 9 | Pset_DuctSegmentTypeCommon - sets with these values: 3
3696661 | P1 | Round | 34.5 | 34.5 | 2 | Level: P1 | 100 mmø | 0.108385 | 10 | Mechanical IC.AIRE.Extracció.Serveis 9
3696899 | P0 | Round | 24.7828 | 24.7828 | 2 | Level: P0 | 150 mmø | 0.116786 | 15 | Mechanical IC.AIRE.Extracció.Serveis 11
3696902 | P0 | Round | 238.694 | 238.694 | 2 | Level: P0 | 100 mmø | 0.749881 | 10 | Mechanical IC.AIRE.Extracció.Serveis 11
3696904 | P0 | Round | 83 | 83 | 2 | Level: P0 | 125 mmø | 0.32594 | 12.5 | Mechanical IC.AIRE.Extracció.Serveis 11
3696912 | P0 |  | 148.717 |  |  | Level: P0 | 150 mmø | 0.700813 | 15 | Mechanical IC.AIRE.Extracció.Serveis 11 | Pset_DuctSegmentTypeCommon - sets with these values: 3
3696916 | P0 | Round | 34.5 | 34.5 | 2 | Level: P0 | 100 mmø | 0.108385 | 10 | Mechanical IC.AIRE.Extracció.Serveis 11
3780843 | P0 | Round | 12.4597 | 12.4597 | 2 | Level: P0 | 90 mmø | 0.035229 | 9 | Mechanical IC.AIRE.Extracció.Serveis 1

# IfcFlowTerminal: AMB.APS01.Inodor:AMB.SAN.Inodor.Descargahorizontal (6)
Type - Classification: 60.10.10.10 Inodors (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 60.10.10.10; 105.AMB.ClassificacioDescripcio: Inodors; 109.AMB.CodiTipus: SAN01; 111.AMB.DescripcioTipus: Inodor
Pset_DistributionFlowElementCommon - Reference: AMB.APS01.Inodor:AMB.SAN.Inodor.Descargahorizontal; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.APS01.Inodor: AMB.SAN.Inodor.Descargahorizontal; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 1.00481 m2; 509.AMB.Volum: 0.106237 m3
Name (AMB.APS01.Inodor:AMB.SAN.Inodor.Descargahorizontal:...) | In | 115.AMB.Nivell | 112.AMB.Servei
3305042 | P1 | Level: P1
3305049 | P1 | Level: P1 | Piping System: IF.SANE.Fecal
3305056 | P1 | Level: P1 | Piping System: IF.SANE.Fecal
3318627 | P0 | Level: P0 | Piping System: IF.SANE.Fecal | Group: IF.SANE.Fecal 7
3318628 | P0 | Level: P0 | Piping System: IF.SANE.Fecal | Group: IF.SANE.Fecal 7
3318629 | P0 | Level: P0 | Piping System: IF.SANE.Fecal | Group: IF.SANE.Fecal 7

# IfcFlowTerminal: AMB.APS02.Lavabo_Mural:AMB.SAN.LavaboMural (8)
Type - Classification: 60.10.10.60 Rentamans (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 60.10.10.60; 105.AMB.ClassificacioDescripcio: Rentamans; 109.AMB.CodiTipus: SAN03; 111.AMB.DescripcioTipus: Lavabo
Pset_DistributionFlowElementCommon - Reference: AMB.APS02.Lavabo_Mural:AMB.SAN.LavaboMural; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.APS02.Lavabo_Mural: AMB.SAN.LavaboMural; 112.AMB.Servei: Piping System: IF.SANE.Fecal; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.439913 m2; 509.AMB.Volum: 0.0174787 m3
Name (AMB.APS02.Lavabo_Mural:AMB.SAN.LavaboMural:...) | In | 115.AMB.Nivell | Group
3314028 | P1 | Level: P1 | IF.SANE.Fecal 7
3314081 | P1 | Level: P1 | IF.SANE.Fecal 7
3314111 | P1 | Level: P1 | IF.SANE.Fecal 7
3314207 | P1 | Level: P1 | IF.SANE.Fecal 3
3318630 | P0 | Level: P0 | IF.SANE.Fecal 3
3318631 | P0 | Level: P0 | IF.SANE.Fecal 3
3318632 | P0 | Level: P0 | IF.SANE.Fecal 3
3318633 | P0 | Level: P0 | IF.SANE.Fecal 15

# IfcFlowTerminal: AMB.Dutxa.Adaptada:AMB.APS05.PlatDutxaAdaptat.80cm, AMB.Dutxa.Adaptada:AMB.APS05.PlatDutxaAdaptat.80cm:3770857
In: P0
Type - Classification: 60.10.10.40 Plats de dutxa (Uniformat); Material: Metal.Acero.Cromado, Cerámica.Porcelana.Blanco
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 60.10.10.40; 105.AMB.ClassificacioDescripcio: Plats de dutxa; 111.AMB.DescripcioTipus: Plat de dutxa de 0.8m d'amplada adaptat
Material: <Unnamed>, Metal.Acero.Cromado; Group: IF.SANE.Fecal 4
Pset_DistributionFlowElementCommon - Reference: AMB.Dutxa.Adaptada:AMB.APS05.PlatDutxaAdaptat.80cm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.Dutxa.Adaptada: AMB.APS05.PlatDutxaAdaptat.80cm; 112.AMB.Servei: Piping System: IF.SANE.Fecal; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 503.AMB.Altura: 8 cm; 507.AMB.Area: 0.313938 m2; 509.AMB.Volum: 0.00148737 m3

# IfcFlowTerminal: AMB.Inodor.Accessible:AMB.SAN.InodorAccesible (2)
Type - Classification: 60.10.10.10 Inodors (Uniformat); Material: <Unnamed>, Default Wall
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 60.10.10.10; 105.AMB.ClassificacioDescripcio: Inodors; 109.AMB.CodiTipus: SAN02; 111.AMB.DescripcioTipus: Inodor accesible
Material: Default Wall, Chrome -Hotels 2.0-Roca, <Unnamed>
Pset_DistributionFlowElementCommon - Reference: AMB.Inodor.Accessible:AMB.SAN.InodorAccesible; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.Inodor.Accessible: AMB.SAN.InodorAccesible; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 1.31639 m2; 509.AMB.Volum: 0.167518 m3
Name (AMB.Inodor.Accessible:AMB.SAN.InodorAccesible:...) | In | 115.AMB.Nivell
3318634 | P0 | Level: P0 | 1 AMB.Identificacio - 112.AMB.Servei: Piping System: IF.SANE.Fecal; Group: IF.SANE.Fecal 7
3543152 | P1 | Level: P1

# IfcFlowTerminal: AMB_Arqueta_MC1:AMB.ELE.Arqueta.FE500x500, AMB_Arqueta_MC1:AMB.ELE.Arqueta.FE500x500:3761675
In: P0
Type - Classification: 50.60.30.50 Arquetes i pous de distribució elèctrica (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.30.50; 105.AMB.ClassificacioDescripcio: Arquetes i pous de distribució elèctrica; 111.AMB.DescripcioTipus: Arqueta
Type - 3 AMB.Fabricant - 302.AMB.Model: Arqueta
Pset_DistributionFlowElementCommon - Reference: AMB_Arqueta_MC1:AMB.ELE.Arqueta.FE500x500; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Arqueta_MC1: AMB.ELE.Arqueta.FE500x500; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 509.AMB.Volum: 0.058384 m3

# IfcFlowTerminal: AMB_Arqueta_MC1:AMB.SAN.ArquetaSifonica.FE400x400, AMB_Arqueta_MC1:AMB.SAN.ArquetaSifonica.FE400x400:3318636
In: P0
Type - Classification: 50.20.20.50 Arquetes i pous d'evaquació d'aigües (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.50; 105.AMB.ClassificacioDescripcio: Arquetes i pous d'evaquació d'aigües; 109.AMB.CodiTipus: SAN04; 111.AMB.DescripcioTipus: Arqueta Sifónica 400X400
Type - 3 AMB.Fabricant - 302.AMB.Model: Arqueta Sifónica 400X400
Pset_DistributionFlowElementCommon - Reference: AMB_Arqueta_MC1:AMB.SAN.ArquetaSifonica.FE400x400; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Arqueta_MC1: AMB.SAN.ArquetaSifonica.FE400x400; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 509.AMB.Volum: 0.039164 m3

# IfcFlowTerminal: AMB_Arqueta_MC1:AMB.SAN.ArquetaSifonica.FE600x600 (2)
In: P0
Type - Classification: 50.20.20.50 Arquetes i pous d'evaquació d'aigües (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.50; 105.AMB.ClassificacioDescripcio: Arquetes i pous d'evaquació d'aigües; 109.AMB.CodiTipus: SAN17; 111.AMB.DescripcioTipus: Arqueta Sifónica 600x600
Type - 3 AMB.Fabricant - 302.AMB.Model: Arqueta Sifónica 600x600
Pset_DistributionFlowElementCommon - Reference: AMB_Arqueta_MC1:AMB.SAN.ArquetaSifonica.FE600x600; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Arqueta_MC1: AMB.SAN.ArquetaSifonica.FE600x600; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
Name (AMB_Arqueta_MC1:AMB.SAN.ArquetaSifonica.FE600x600:...) | 509.AMB.Volum (m3)
3320993 | 0.076524 | 1 AMB.Identificacio - 112.AMB.Servei: Piping System: IF.SANE.Pluvial; Group: IF.SANE.Pluvial 5
3538188 | 0.066764

# IfcFlowTerminal: AMB_BIE_Armari1:AMB.PCI.BIEArmari (4)
