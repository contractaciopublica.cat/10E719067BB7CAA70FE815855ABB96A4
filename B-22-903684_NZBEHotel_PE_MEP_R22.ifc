Properties of the parts of a building model (IFC2X3), part 3 of 7

# IfcDistributionPort (3289)
Name | FlowDirection | Group
OutPort_3696906 | SOURCE | Mechanical IC.AIRE.Extracció.Serveis 11
Port_3696901 | SOURCEANDSINK
InPort_3696906 | SINK | Mechanical IC.AIRE.Extracció.Serveis 11
OutPort_3696901 | SOURCE | Mechanical IC.AIRE.Extracció.Serveis 11
InPort_3696901 | SINK | Mechanical IC.AIRE.Extracció.Serveis 11
OutPort_3696910 | SOURCE | Mechanical IC.AIRE.Extracció.Serveis 11
InPort_3696902 | SINK | Mechanical IC.AIRE.Extracció.Serveis 11
OutPort_3696920 | SOURCE | Mechanical IC.AIRE.Extracció.Serveis 11
Port_3696902 | SOURCEANDSINK | Mechanical IC.AIRE.Extracció.Serveis 11
InPort_3696902 | SOURCEANDSINK | Mechanical IC.AIRE.Extracció.Serveis 11
2 x OutPort_3776788 | SOURCEANDSINK | Mechanical IC.AIRE.Extracció.Serveis 11
2 x InPort_3696904 | SOURCEANDSINK | Mechanical IC.AIRE.Extracció.Serveis 11
2 x OutPort_3696914 | SOURCEANDSINK | Mechanical IC.AIRE.Extracció.Serveis 11
InPort_3696904 | SINK | Mechanical IC.AIRE.Extracció.Serveis 11
OutPort_3696921 | SOURCE | Mechanical IC.AIRE.Extracció.Serveis 11
2 x OutPort_3696918 | SOURCEANDSINK | Mechanical IC.AIRE.Extracció.Serveis 11
InPort_3696910 | SINK | Mechanical IC.AIRE.Extracció.Serveis 11
OutPort_3696912 | SOURCE | Mechanical IC.AIRE.Extracció.Serveis 11
2 x InPort_3696912 | SOURCEANDSINK | Mechanical IC.AIRE.Extracció.Serveis 11
InPort_3696912 | SINK | Mechanical IC.AIRE.Extracció.Serveis 11
OutPort_3696923 | SOURCE | Mechanical IC.AIRE.Extracció.Serveis 11
InPort_3696916 | SOURCEANDSINK | Mechanical IC.AIRE.Extracció.Serveis 11
Port_3696916 | SOURCEANDSINK | Mechanical IC.AIRE.Extracció.Serveis 11
InPort_3696916 | SINK | Mechanical IC.AIRE.Extracció.Serveis 11
OutPort_3696922 | SOURCE | Mechanical IC.AIRE.Extracció.Serveis 11
InPort_3697055 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3697056 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3699077 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3697055 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3697056 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3699076 | SOURCE | Mechanical IC.AIRE.Aportació 3
3 x Port_3697058 | SOURCEANDSINK
InPort_3697058 | SINK | Mechanical IC.AIRE.ExtraccióPrimari 4
OutPort_3697068 | SOURCE | Mechanical IC.AIRE.ExtraccióPrimari 4
Port_3697058 | SINK
InPort_3697058 | SINK | Mechanical IC.AIRE.ExtraccióPrimari 1
OutPort_3697066 | SOURCE | Mechanical IC.AIRE.ExtraccióPrimari 1
InPort_3697062 | SINK | Mechanical IC.AIRE.Aportació 2
OutPort_3697058 | SOURCE | Mechanical IC.AIRE.Aportació 2
InPort_3697064 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3697058 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3697059 | SINK | Mechanical IC.AIRE.Aportació 2
OutPort_3697071 | SOURCE | Mechanical IC.AIRE.Aportació 2
InPort_3697070 | SINK | Mechanical IC.AIRE.Aportació 2
OutPort_3697059 | SOURCE | Mechanical IC.AIRE.Aportació 2
InPort_3697069 | SINK | Mechanical IC.AIRE.ExtraccióPrimari 4
OutPort_3697060 | SOURCE | Mechanical IC.AIRE.ExtraccióPrimari 4
Port_3697060 | SOURCE | Mechanical IC.AIRE.ExtraccióPrimari 4
InPort_3697061 | SINK | Mechanical IC.AIRE.Aportació 2
OutPort_3697062 | SOURCE | Mechanical IC.AIRE.Aportació 2
InPort_3697071 | SINK | Mechanical IC.AIRE.Aportació 2
OutPort_3697061 | SOURCE | Mechanical IC.AIRE.Aportació 2
InPort_3697063 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3697064 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3697072 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3697063 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3697066 | SINK | Mechanical IC.AIRE.ExtraccióPrimari 1
OutPort_3697065 | SOURCE | Mechanical IC.AIRE.ExtraccióPrimari 1
InPort_3697065 | SINK | Mechanical IC.AIRE.ExtraccióPrimari 1
OutPort_3773589 | SOURCE | Mechanical IC.AIRE.ExtraccióPrimari 1
InPort_3697067 | SINK | Mechanical IC.AIRE.ExtraccióPrimari 4
OutPort_3697069 | SOURCE | Mechanical IC.AIRE.ExtraccióPrimari 4
InPort_3697068 | SINK | Mechanical IC.AIRE.ExtraccióPrimari 4
OutPort_3697067 | SOURCE | Mechanical IC.AIRE.ExtraccióPrimari 4
InPort_3697075 | SINK | Mechanical IC.AIRE.Aportació 2
OutPort_3697070 | SOURCE | Mechanical IC.AIRE.Aportació 2
InPort_3697078 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3697072 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3697074 | SINK | Mechanical IC.AIRE.ExtraccióPrimari 1
OutPort_3782069 | SOURCE | Mechanical IC.AIRE.ExtraccióPrimari 1
Port_3697074 | SOURCEANDSINK | Mechanical IC.AIRE.ExtraccióPrimari 1
InPort_3773589 | SINK | Mechanical IC.AIRE.ExtraccióPrimari 1
OutPort_3697074 | SOURCE | Mechanical IC.AIRE.ExtraccióPrimari 1
Port_3697075 | SINK | Mechanical IC.AIRE.Aportació 2
InPort_3697076 | SINK | Mechanical IC.AIRE.Aportació 3
2 x OutPort_3697077 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3697100 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3697076 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3779152 | SINK | Mechanical IC.AIRE.Aportació 3
InPort_3697077 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3697078 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3697082 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3779152 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3779153 | SINK | Mechanical IC.AIRE.Aportació 3
2 x OutPort_3697082 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3699200 | SINK | Mechanical IC.AIRE.Aportació 3
InPort_3697085 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3699077 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3697086 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3777674 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3697096 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3697100 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3697987 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3778196 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3778719 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3697987 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3698009 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3698046 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3778196 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3698009 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3698046 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3779102 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3778773 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3698073 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3698073 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3778734 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3698076 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3778764 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3698214 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3698196 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3698196 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3778194 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3698792 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3698207 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3698207 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3698214 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3777715 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3698638 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3698638 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3777716 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3698660 | SINK | Mechanical IC.AIRE.Aportació 3
2 x OutPort_3699014 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3699052 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3698660 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3782818 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3698792 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3699001 | SINK | Mechanical IC.AIRE.Aportació 3
InPort_3699162 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3699001 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3699014 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3699015 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3699015 | SINK | Mechanical IC.AIRE.Aportació 3
2 x OutPort_3777705 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3699045 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3699052 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3699076 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3699045 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3699160 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3699162 | SOURCE | Mechanical IC.AIRE.Aportació 3
2 x InPort_3700903 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3700995 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3701069 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3700948 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3701027 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3701027 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3701028 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3701028 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3783610 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3701058 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3712754 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3701499 | SINK | IF.FONT.AFS 5
OutPort_3701156 | SOURCE | IF.FONT.AFS 5
InPort_3701156 | SINK | IF.FONT.AFS 5
OutPort_3701176 | SOURCE | IF.FONT.AFS 5
InPort_3701170 | SINK | IF.FONT.AFS 5
OutPort_3701189 | SOURCE | IF.FONT.AFS 5
InPort_3701176 | SINK | IF.FONT.AFS 5
OutPort_3701170 | SOURCE | IF.FONT.AFS 5
InPort_3701179 | SINK | IF.FONT.AFS 5
OutPort_3701400 | SOURCE | IF.FONT.AFS 5
InPort_3701189 | SINK | IF.FONT.AFS 5
OutPort_3701179 | SOURCE | IF.FONT.AFS 5
InPort_3701543 | SINK | IF.FONT.AFS 5
OutPort_3701192 | SOURCE | IF.FONT.AFS 5
InPort_3701192 | SINK | IF.FONT.AFS 5
OutPort_3701383 | SOURCE | IF.FONT.AFS 5
InPort_3701400 | SINK | IF.FONT.AFS 5
OutPort_3701557 | SOURCE | IF.FONT.AFS 5
InPort_3701507 | SINK | IF.FONT.AFS 5
OutPort_3701495 | SOURCE | IF.FONT.AFS 5
InPort_3701495 | SINK | IF.FONT.AFS 5
OutPort_3701497 | SOURCE | IF.FONT.AFS 5
InPort_3701497 | SINK | IF.FONT.AFS 5
OutPort_3701499 | SOURCE | IF.FONT.AFS 5
InPort_3701535 | SINK | IF.FONT.AFS 5
OutPort_3701543 | SOURCE | IF.FONT.AFS 5
InPort_3701541 | SINK | IF.FONT.AFS 5
OutPort_3701535 | SOURCE | IF.FONT.AFS 5
InPort_3701537 | SINK | IF.FONT.AFS 5
OutPort_3701541 | SOURCE | IF.FONT.AFS 5
InPort_3703507 | SINK | IF.FONT.AFS 5
OutPort_3701537 | SOURCE | IF.FONT.AFS 5
InPort_3701559 | SINK | IF.FONT.AFS 5
OutPort_3701555 | SOURCE | IF.FONT.AFS 5
InPort_3701555 | SINK | IF.FONT.AFS 5
OutPort_3701561 | SOURCE | IF.FONT.AFS 5
InPort_3701557 | SINK | IF.FONT.AFS 5
OutPort_3701559 | SOURCE | IF.FONT.AFS 5
InPort_3701561 | SINK | IF.FONT.AFS 5
OutPort_3703502 | SOURCE | IF.FONT.AFS 5
InPort_3703504 | SINK | IF.FONT.AFS 5
OutPort_3703500 | SOURCE | IF.FONT.AFS 5
InPort_3703500 | SINK | IF.FONT.AFS 5
OutPort_3703507 | SOURCE | IF.FONT.AFS 5
InPort_3703502 | SINK | IF.FONT.AFS 5
OutPort_3703504 | SOURCE | IF.FONT.AFS 5
3 x InPort_3703662 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3704836 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3703681 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3703782 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3703683 | SOURCEANDSINK | IF.FONT.ACS 2
2 x OutPort_3703778 | SOURCEANDSINK | IF.FONT.ACS 2
2 x InPort_3703720 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3703722 | SOURCEANDSINK | IF.FONT.ACS 2
2 x InPort_3703819 | SOURCEANDSINK | IF.FONT.ACS 2
2 x OutPort_3704798 | SOURCEANDSINK | IF.FONT.ACS 2
OutPort_3704829 | SOURCEANDSINK | IF.FONT.ACS 2
InPort_3703891 | SOURCEANDSINK | IF.FONT.ACS 2
2 x OutPort_3704830 | SOURCEANDSINK | IF.FONT.ACS 2
InPort_3703908 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3704087 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3703916 | SOURCEANDSINK | IF.FONT.ACS 2
OutPort_3704196 | SOURCEANDSINK | IF.FONT.ACS 2
InPort_3703938 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3704171 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3703939 | SOURCEANDSINK | IF.FONT.ACS 2
OutPort_3704212 | SOURCEANDSINK | IF.FONT.ACS 2
InPort_3703961 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3704153 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3703980 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3704133 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3704012 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3704115 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3704087 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3704882 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3704115 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3704893 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3704133 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3704377 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3704153 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3704474 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3704171 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3704463 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3704196 | SOURCEANDSINK | IF.FONT.ACS 2
2 x OutPort_3704336 | SOURCEANDSINK | IF.FONT.ACS 2
InPort_3704212 | SOURCEANDSINK | IF.FONT.ACS 2
2 x OutPort_3704576 | SOURCEANDSINK | IF.FONT.ACS 2
2 x InPort_3704316 | SOURCEANDSINK | IF.FONT.ACS 2
OutPort_3705049 | SOURCEANDSINK | IF.FONT.ACS 2
2 x OutPort_3704833 | SOURCEANDSINK | IF.FONT.ACS 2
2 x InPort_3704325 | SOURCEANDSINK | IF.FONT.ACS 2
2 x OutPort_3704340 | SOURCEANDSINK | IF.FONT.ACS 2
2 x InPort_3704334 | SOURCEANDSINK | IF.FONT.ACS 2
2 x InPort_3704366 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3704381 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3704375 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3704426 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3704716 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3704448 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3704435 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3704461 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3704470 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3704448 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3704471 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3704459 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3704468 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3704470 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3704557 | SOURCEANDSINK | IF.FONT.ACS 2
OutPort_3704611 | SOURCEANDSINK | IF.FONT.ACS 2
2 x OutPort_3704578 | SOURCEANDSINK | IF.FONT.ACS 2
2 x InPort_3704574 | SOURCEANDSINK | IF.FONT.ACS 2
2 x InPort_3704601 | SOURCEANDSINK | IF.FONT.ACS 2
2 x OutPort_3707955 | SOURCEANDSINK | IF.FONT.ACS 2
OutPort_3704674 | SOURCEANDSINK | IF.FONT.ACS 2
InPort_3704611 | SOURCEANDSINK | IF.FONT.ACS 2
2 x OutPort_3704676 | SOURCEANDSINK | IF.FONT.ACS 2
InPort_3704674 | SOURCEANDSINK | IF.FONT.ACS 2
InPort_3704716 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3704718 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3704718 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3704942 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3704775 | SOURCEANDSINK | IF.FONT.ACS 2
2 x InPort_3704829 | SOURCEANDSINK | IF.FONT.ACS 2
2 x OutPort_3705051 | SOURCEANDSINK | IF.FONT.ACS 2
2 x InPort_3704835 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3704843 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3704843 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3705085 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3704863 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3704921 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3704891 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3704880 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3704884 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3704884 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3704922 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3704889 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3704913 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3708037 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3704944 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3704921 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3704976 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3704925 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3704944 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3704945 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3704945 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3708357 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3704974 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3708358 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3705049 | SOURCEANDSINK | IF.FONT.ACS 2
InPort_3705083 | SOURCEANDSINK | IF.FONT.AFS 5
Port_3705201 | SOURCE | IF.FONT.AFS 5
Port_3705201 | SINK | IF.FONT.ACS 2
InPort_3706659 | SOURCEANDSINK | IF.FONT.ACS 2
2 x OutPort_3708262 | SOURCEANDSINK | IF.FONT.ACS 2
Port_3706659 | SOURCEANDSINK | IF.FONT.ACS 2
Port_3707891 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3707891 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3771944 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3707930 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3708361 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3707955 | SOURCEANDSINK | IF.FONT.ACS 2
OutPort_3707966 | SOURCEANDSINK | IF.FONT.ACS 2
InPort_3707966 | SOURCEANDSINK | IF.FONT.ACS 2
2 x OutPort_3708326 | SOURCEANDSINK | IF.FONT.ACS 2
2 x InPort_3708135 | SOURCEANDSINK | IF.FONT.ACS 2
2 x OutPort_3708334 | SOURCEANDSINK | IF.FONT.ACS 2
2 x OutPort_3708336 | SOURCEANDSINK | IF.FONT.ACS 2
2 x InPort_3708178 | SOURCEANDSINK | IF.FONT.ACS 2
2 x InPort_3708215 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3708349 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3708324 | SOURCEANDSINK | IF.FONT.ACS 2
2 x InPort_3708345 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3708357 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3709529 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3709577 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3709561 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709531 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3709539 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709532 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3709543 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709533 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3709547 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709534 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3709567 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709535 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3709569 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709536 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3709571 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709537 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3709573 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709538 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3709575 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709539 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3709553 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3709540 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3709551 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709543 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3709559 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3709544 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3709555 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709547 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3709565 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3709548 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709551 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3709556 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3709555 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3709562 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709561 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709567 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3709585 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709569 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3709593 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709571 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3709605 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709573 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3709611 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709575 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3709635 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709577 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3709582 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3709579 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3709581 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3709581 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3709590 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3709587 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3709589 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3709589 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3709595 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709595 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3709600 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3709597 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3709603 | SOURCEANDSINK | IF.FONT.AFS 5
3 x InPort_3709599 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3709613 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3709607 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3709623 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3709621 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3709609 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709613 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3709615 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709615 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3710876 | SOURCEANDSINK | IF.FONT.AFS 5
3 x InPort_3709617 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3709625 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3709618 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709618 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3710953 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3709625 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3709630 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3709627 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3709633 | SOURCEANDSINK | IF.FONT.AFS 5
3 x InPort_3709629 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3712723 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3709996 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3710013 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3712729 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3710004 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3710470 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3710015 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3710528 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3710042 | SOURCEANDSINK | IF.FONT.ACS 4
OutPort_3710495 | SOURCEANDSINK | IF.FONT.ACS 4
2 x OutPort_3710059 | SOURCEANDSINK | IF.FONT.ACS 4
2 x InPort_3710051 | SOURCEANDSINK | IF.FONT.ACS 4
OutPort_3710068 | SOURCEANDSINK | IF.FONT.ACS 4
2 x InPort_3710062 | SOURCEANDSINK | IF.FONT.ACS 4
2 x OutPort_3710934 | SOURCEANDSINK | IF.FONT.ACS 4
2 x OutPort_3711068 | SOURCEANDSINK | IF.FONT.ACS 4
InPort_3710068 | SOURCEANDSINK | IF.FONT.ACS 4
2 x OutPort_3711069 | SOURCEANDSINK | IF.FONT.ACS 4
InPort_3710137 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3710174 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3710138 | SOURCEANDSINK | IF.FONT.ACS 4
OutPort_3710199 | SOURCEANDSINK | IF.FONT.ACS 4
InPort_3710174 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3710520 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3710199 | SOURCEANDSINK | IF.FONT.ACS 4
2 x OutPort_3710487 | SOURCEANDSINK | IF.FONT.ACS 4
2 x InPort_3710441 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3712617 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3710530 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3710443 | SOURCEANDSINK | IF.FONT.ACS 4
2 x OutPort_3710497 | SOURCEANDSINK | IF.FONT.ACS 4
OutPort_3712601 | SOURCEANDSINK | IF.FONT.ACS 4
2 x InPort_3710485 | SOURCEANDSINK | IF.FONT.ACS 4
InPort_3710495 | SOURCEANDSINK | IF.FONT.ACS 4
2 x OutPort_3712603 | SOURCEANDSINK | IF.FONT.ACS 4
2 x InPort_3710518 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3710528 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3712619 | SOURCEANDSINK | IF.FONT.AFS 5
Port_3710543 | SOURCE | IF.FONT.ACS 4
Port_3710543 | SINK | IF.FONT.AFS 5
InPort_3710618 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3710620 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3710619 | SOURCEANDSINK | IF.FONT.ACS 4
OutPort_3710622 | SOURCEANDSINK | IF.FONT.ACS 4
InPort_3710620 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3710822 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3710622 | SOURCEANDSINK | IF.FONT.ACS 4
2 x OutPort_3710855 | SOURCEANDSINK | IF.FONT.ACS 4
2 x InPort_3710740 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3710879 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3710875 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3710769 | SOURCEANDSINK | IF.FONT.ACS 4
2 x OutPort_3710936 | SOURCEANDSINK | IF.FONT.ACS 4
2 x InPort_3710820 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3710824 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3710822 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3710853 | SOURCEANDSINK | IF.FONT.ACS 4
2 x InPort_3710875 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3710954 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3710945 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3710961 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3712496 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3710953 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3711010 | SOURCEANDSINK | IF.FONT.ACS 4
OutPort_3712573 | SOURCEANDSINK | IF.FONT.ACS 4
2 x OutPort_3712464 | SOURCEANDSINK | IF.FONT.ACS 4
2 x InPort_3711021 | SOURCEANDSINK | IF.FONT.ACS 4
OutPort_3712462 | SOURCEANDSINK | IF.FONT.ACS 4
InPort_3711068 | SOURCEANDSINK | IF.FONT.ACS 4
Port_3712245 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3712245 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3712502 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3712268 | SOURCEANDSINK | IF.FONT.ACS 4
OutPort_3712312 | SOURCEANDSINK | IF.FONT.ACS 4
Port_3712268 | SOURCEANDSINK | IF.FONT.ACS 4
2 x InPort_3712287 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3712543 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3712504 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3712312 | SOURCEANDSINK | IF.FONT.ACS 4
OutPort_3712314 | SOURCEANDSINK | IF.FONT.ACS 4
InPort_3712314 | SOURCEANDSINK | IF.FONT.ACS 4
OutPort_3712402 | SOURCEANDSINK | IF.FONT.ACS 4
InPort_3712402 | SOURCEANDSINK | IF.FONT.ACS 4
2 x OutPort_3712451 | SOURCEANDSINK | IF.FONT.ACS 4
2 x InPort_3712449 | SOURCEANDSINK | IF.FONT.ACS 4
InPort_3712462 | SOURCEANDSINK | IF.FONT.ACS 4
2 x OutPort_3712575 | SOURCEANDSINK | IF.FONT.ACS 4
2 x InPort_3712494 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3712498 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3712498 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3712545 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3712502 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3712543 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3712573 | SOURCEANDSINK | IF.FONT.ACS 4
InPort_3712601 | SOURCEANDSINK | IF.FONT.ACS 4
InPort_3712617 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3712655 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3712657 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3712708 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3712657 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3712680 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3712758 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3712689 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3712707 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3712707 | SOURCEANDSINK | IF.FONT.AFS 5
2 x Port_3746210 | SOURCEANDSINK
2 x Port_3746279 | SOURCEANDSINK
2 x Port_3746324 | SOURCEANDSINK
2 x Port_3746381 | SOURCEANDSINK
2 x InPort_3746487 | SOURCEANDSINK
2 x OutPort_3747122 | SOURCEANDSINK
InPort_3746497 | SOURCEANDSINK
2 x InPort_3747027 | SOURCEANDSINK
2 x OutPort_3747119 | SOURCEANDSINK
InPort_3747108 | SOURCEANDSINK
Port_3747108 | SOURCEANDSINK
Port_3751295 | SOURCEANDSINK
Port_3753531 | SOURCEANDSINK
Port_3753540 | SOURCEANDSINK
Port_3753621 | SOURCEANDSINK
Port_3753634 | SOURCEANDSINK
Port_3753642 | SOURCEANDSINK
Port_3753652 | SOURCEANDSINK
Port_3753677 | SOURCEANDSINK
2 x InPort_3755763 | SOURCEANDSINK
OutPort_3755845 | SOURCEANDSINK
OutPort_3755847 | SOURCEANDSINK
Port_3755845 | SOURCEANDSINK
Port_3755847 | SOURCEANDSINK
2 x InPort_3756199 | SOURCEANDSINK
OutPort_3756200 | SOURCEANDSINK
OutPort_3756202 | SOURCEANDSINK
Port_3756200 | SOURCEANDSINK
Port_3756202 | SOURCEANDSINK
2 x InPort_3756216 | SOURCEANDSINK
OutPort_3756219 | SOURCEANDSINK
OutPort_3756217 | SOURCEANDSINK
Port_3756217 | SOURCEANDSINK
Port_3756219 | SOURCEANDSINK
2 x InPort_3756231 | SOURCEANDSINK
OutPort_3756234 | SOURCEANDSINK
OutPort_3756232 | SOURCEANDSINK
Port_3756232 | SOURCEANDSINK
Port_3756234 | SOURCEANDSINK
2 x InPort_3756248 | SOURCEANDSINK
OutPort_3756251 | SOURCEANDSINK
OutPort_3756249 | SOURCEANDSINK
Port_3756249 | SOURCEANDSINK
Port_3756251 | SOURCEANDSINK
2 x InPort_3756263 | SOURCEANDSINK
OutPort_3756264 | SOURCEANDSINK
OutPort_3756266 | SOURCEANDSINK
Port_3756264 | SOURCEANDSINK
Port_3756266 | SOURCEANDSINK
2 x InPort_3756278 | SOURCEANDSINK
OutPort_3756281 | SOURCEANDSINK
OutPort_3756279 | SOURCEANDSINK
Port_3756279 | SOURCEANDSINK
Port_3756281 | SOURCEANDSINK
2 x InPort_3756295 | SOURCEANDSINK
OutPort_3756298 | SOURCEANDSINK
OutPort_3756296 | SOURCEANDSINK
Port_3756296 | SOURCEANDSINK
Port_3756298 | SOURCEANDSINK
2 x InPort_3756322 | SOURCEANDSINK
OutPort_3756325 | SOURCEANDSINK
OutPort_3756323 | SOURCEANDSINK
Port_3756323 | SOURCEANDSINK
Port_3756325 | SOURCEANDSINK
2 x InPort_3756337 | SOURCEANDSINK
OutPort_3756338 | SOURCEANDSINK
OutPort_3756340 | SOURCEANDSINK
Port_3756338 | SOURCEANDSINK
Port_3756340 | SOURCEANDSINK
2 x InPort_3756352 | SOURCEANDSINK
OutPort_3756353 | SOURCEANDSINK
OutPort_3756355 | SOURCEANDSINK
Port_3756353 | SOURCEANDSINK
Port_3756355 | SOURCEANDSINK
2 x InPort_3756365 | SOURCEANDSINK
OutPort_3756366 | SOURCEANDSINK
OutPort_3756368 | SOURCEANDSINK
Port_3756366 | SOURCEANDSINK
Port_3756368 | SOURCEANDSINK
2 x InPort_3756378 | SOURCEANDSINK
OutPort_3756379 | SOURCEANDSINK
OutPort_3756381 | SOURCEANDSINK
Port_3756379 | SOURCEANDSINK
Port_3756381 | SOURCEANDSINK
2 x InPort_3756391 | SOURCEANDSINK
OutPort_3756394 | SOURCEANDSINK
OutPort_3756392 | SOURCEANDSINK
Port_3756392 | SOURCEANDSINK
Port_3756394 | SOURCEANDSINK
Port_3756526 | SOURCEANDSINK
InPort_3756526 | SOURCEANDSINK
2 x OutPort_3756544 | SOURCEANDSINK
2 x InPort_3756535 | SOURCEANDSINK
2 x OutPort_3756561 | SOURCEANDSINK
2 x InPort_3756547 | SOURCEANDSINK
OutPort_3756573 | SOURCEANDSINK
Port_3756573 | SOURCEANDSINK
3 x Port_3761675 | SOURCE
Port_3761675 | SINK
InPort_3766284 | SOURCEANDSINK | IG.Gas 2
2 x OutPort_3766304 | SOURCEANDSINK | IG.Gas 2
2 x InPort_3766296 | SOURCEANDSINK | IG.Gas 2
OutPort_3766312 | SOURCEANDSINK | IG.Gas 2
2 x InPort_3766306 | SOURCEANDSINK | IG.Gas 2
2 x OutPort_3766327 | SOURCEANDSINK | IG.Gas 2
2 x OutPort_3766697 | SOURCEANDSINK | IG.Gas 2
InPort_3766312 | SOURCEANDSINK | IG.Gas 2
OutPort_3766522 | SOURCEANDSINK | IG.Gas 2
2 x InPort_3766316 | SOURCEANDSINK | IG.Gas 2
2 x InPort_3766520 | SOURCEANDSINK | IG.Gas 2
2 x OutPort_3766524 | SOURCEANDSINK | IG.Gas 2
OutPort_3766526 | SOURCEANDSINK | IG.Gas 2
InPort_3766522 | SOURCEANDSINK | IG.Gas 2
InPort_3766526 | SOURCEANDSINK | IG.Gas 2
OutPort_3766693 | SOURCEANDSINK | IG.Gas 2
2 x InPort_3766691 | SOURCEANDSINK | IG.Gas 2
2 x OutPort_3766695 | SOURCEANDSINK | IG.Gas 2
InPort_3766693 | SOURCEANDSINK | IG.Gas 2
2 x InPort_3770853 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x OutPort_3770927 | SOURCEANDSINK | IF.SANE.Fecal 4
OutPort_3770923 | SOURCEANDSINK | IF.SANE.Fecal 4
InPort_3770903 | SINK | IF.SANE.Fecal 4
OutPort_3770857 | SOURCE | IF.SANE.Fecal 4
InPort_3770858 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x OutPort_3770941 | SOURCEANDSINK | IF.SANE.Fecal 4
InPort_3770967 | SINK | IF.SANE.Fecal 4
OutPort_3770860 | SOURCE | IF.SANE.Fecal 4
InPort_3770862 | SINK | IF.SANE.Fecal 4
OutPort_3770967 | SOURCE | IF.SANE.Fecal 4
InPort_3770965 | SINK | IF.SANE.Fecal 4
OutPort_3770862 | SOURCE | IF.SANE.Fecal 4
InPort_3770865 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x OutPort_3770869 | SOURCEANDSINK | IF.SANE.Fecal 4
Port_3770865 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x InPort_3770867 | SOURCEANDSINK | IF.SANE.Fecal 4
OutPort_3770873 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x InPort_3770871 | SOURCEANDSINK | IF.SANE.Fecal 4
OutPort_3770945 | SOURCEANDSINK | IF.SANE.Fecal 4
InPort_3770873 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x OutPort_3770958 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x InPort_3770875 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x OutPort_3770931 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x OutPort_3770881 | SOURCEANDSINK | IF.SANE.Fecal 4
3 x InPort_3770877 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x OutPort_3770892 | SOURCEANDSINK | IF.SANE.Fecal 4
OutPort_3770878 | SOURCEANDSINK | IF.SANE.Fecal 4
InPort_3770878 | SOURCEANDSINK | IF.SANE.Fecal 4
OutPort_3770957 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x InPort_3770883 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x OutPort_3770889 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x OutPort_3770939 | SOURCEANDSINK | IF.SANE.Fecal 4
3 x InPort_3770885 | SOURCEANDSINK | IF.SANE.Fecal 4
OutPort_3770886 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x OutPort_3770914 | SOURCEANDSINK | IF.SANE.Fecal 4
InPort_3770886 | SOURCEANDSINK | IF.SANE.Fecal 4
OutPort_3770891 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x InPort_3770891 | SOURCEANDSINK | IF.SANE.Fecal 4
OutPort_3770895 | SOURCEANDSINK | IF.SANE.Fecal 4
InPort_3770895 | SOURCEANDSINK | IF.SANE.Fecal 4
OutPort_3770897 | SOURCEANDSINK | IF.SANE.Fecal 4
InPort_3770897 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x OutPort_3770901 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x InPort_3770899 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x OutPort_3770935 | SOURCEANDSINK | IF.SANE.Fecal 4
InPort_3770963 | SINK | IF.SANE.Fecal 4
OutPort_3770903 | SOURCE | IF.SANE.Fecal 4
2 x InPort_3770905 | SOURCEANDSINK | IF.SANE.Fecal 4
OutPort_3770907 | SOURCEANDSINK | IF.SANE.Fecal 4
OutPort_3770913 | SOURCEANDSINK | IF.SANE.Fecal 4
InPort_3770907 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x OutPort_3770946 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x InPort_3770909 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x OutPort_3770917 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x OutPort_3770925 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x InPort_3770911 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x OutPort_3770919 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x InPort_3770913 | SOURCEANDSINK | IF.SANE.Fecal 4
2 x InPort_3770921 | SOURCEANDSINK | IF.SANE.Fecal 4
Port_3770923 | SOURCEANDSINK | IF.SANE.Fecal 4
Port_3770929 | SOURCEANDSINK | IF.SANE.Fecal 4
InPort_3770929 | SOURCEANDSINK | IF.SANE.Fecal 4
InPort_3770933 | SOURCEANDSINK | IF.SANE.Fecal 4
Port_3770933 | SOURCEANDSINK | IF.SANE.Fecal 4
InPort_3770937 | SOURCEANDSINK | IF.SANE.Fecal 4
Port_3770937 | SOURCEANDSINK | IF.SANE.Fecal 4
InPort_3770949 | SINK | IF.SANE.Fecal 4
OutPort_3770943 | SOURCE | IF.SANE.Fecal 4
InPort_3770943 | SINK | IF.SANE.Fecal 4
OutPort_3770953 | SOURCE | IF.SANE.Fecal 4
InPort_3770945 | SOURCEANDSINK | IF.SANE.Fecal 4
InPort_3770945 | SINK | IF.SANE.Fecal 4
OutPort_3770949 | SOURCE | IF.SANE.Fecal 4
InPort_3770951 | SINK | IF.SANE.Fecal 4
OutPort_3770965 | SOURCE | IF.SANE.Fecal 4
InPort_3770953 | SINK | IF.SANE.Fecal 4
OutPort_3770951 | SOURCE | IF.SANE.Fecal 4
InPort_3770961 | SINK | IF.SANE.Fecal 4
OutPort_3770955 | SOURCE | IF.SANE.Fecal 4
InPort_3770955 | SINK | IF.SANE.Fecal 4
OutPort_3770963 | SOURCE | IF.SANE.Fecal 4
InPort_3770957 | SINK | IF.SANE.Fecal 4
OutPort_3770961 | SOURCE | IF.SANE.Fecal 4
InPort_3770957 | SOURCEANDSINK | IF.SANE.Fecal 4
Port_3772537 | SOURCEANDSINK
Port_3772591 | SOURCEANDSINK
InPort_3773055 | SOURCEANDSINK | IC.AIGUA.Calenta.Retorn 3
2 x OutPort_3773313 | SOURCEANDSINK | IC.AIGUA.Calenta.Retorn 3
InPort_3773163 | SOURCEANDSINK | IC.AIGUA.Calenta.Impulsió 3
2 x OutPort_3773279 | SOURCEANDSINK | IC.AIGUA.Calenta.Impulsió 3
2 x InPort_3773267 | SOURCEANDSINK | IC.AIGUA.Calenta.Impulsió 3
2 x InPort_3773301 | SOURCEANDSINK | IC.AIGUA.Calenta.Retorn 3
Port_3774954 | SOURCEANDSINK
Port_3774963 | SOURCEANDSINK
InPort_3775097 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3775386 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3775374 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3776276 | SOURCE | IF.SANE.Fecal 2
InPort_3776202 | SINK | IF.SANE.Fecal 2
OutPort_3776201 | SOURCE | IF.SANE.Fecal 2
InPort_3776276 | SINK | IF.SANE.Fecal 2
OutPort_3776275 | SOURCE | IF.SANE.Fecal 2
OutPort_3776319 | SOURCE | IF.SANE.Fecal 2
InPort_3777674 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3777715 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3777716 | SINK | Mechanical IC.AIRE.Aportació 3
InPort_3777705 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3777706 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3777706 | SINK | Mechanical IC.AIRE.Aportació 3
2 x OutPort_3782817 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3778194 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3778720 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3778734 | SINK | Mechanical IC.AIRE.Aportació 3
2 x OutPort_3778719 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3778720 | SINK | Mechanical IC.AIRE.Aportació 3
InPort_3778764 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3778773 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3779102 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3779153 | SOURCE | Mechanical IC.AIRE.Aportació 3
Port_3779386 | SOURCEANDSINK
2 x InPort_3780282 | SINK | Mechanical IC.AIRE.Extracció 1
OutPort_3780031 | SOURCE | Mechanical IC.AIRE.Extracció 1
InPort_3780279 | SINK | Mechanical IC.AIRE.Extracció 1
OutPort_3780260 | SOURCE | Mechanical IC.AIRE.Extracció 1
OutPort_3780279 | SOURCE | Mechanical IC.AIRE.Extracció 1
InPort_3780031 | SINK | Mechanical IC.AIRE.Extracció 1
OutPort_3780282 | SOURCE | Mechanical IC.AIRE.Extracció 1
2 x InPort_3780364 | SOURCEANDSINK
OutPort_3780367 | SOURCEANDSINK
OutPort_3780365 | SOURCEANDSINK
Port_3780365 | SOURCEANDSINK
Port_3780367 | SOURCEANDSINK
InPort_3780641 | SINK | Mechanical IC.AIRE.Extracció 2
OutPort_3780450 | SOURCE | Mechanical IC.AIRE.Extracció 2
InPort_3780594 | SINK | Mechanical IC.AIRE.Extracció.Serveis 4
OutPort_3780638 | SOURCE | Mechanical IC.AIRE.Extracció.Serveis 4
InPort_3780638 | SINK | Mechanical IC.AIRE.Extracció 2
OutPort_3780641 | SOURCE | Mechanical IC.AIRE.Extracció 2
InPort_3780898 | SINK | Mechanical IC.AIRE.Extracció.Serveis 1
OutPort_3780785 | SOURCE | Mechanical IC.AIRE.Extracció.Serveis 1
InPort_3780843 | SINK | Mechanical IC.AIRE.Extracció.Serveis 1
OutPort_3780895 | SOURCE | Mechanical IC.AIRE.Extracció.Serveis 1
InPort_3780864 | SINK | Mechanical IC.AIRE.Extracció.Serveis 1
OutPort_3780843 | SOURCE | Mechanical IC.AIRE.Extracció.Serveis 1
InPort_3780895 | SINK | Mechanical IC.AIRE.Extracció.Serveis 1
OutPort_3780898 | SOURCE | Mechanical IC.AIRE.Extracció.Serveis 1
InPort_3781629 | SINK | Mechanical IC.AIRE.ExtraccióPrimari 2
OutPort_3781095 | SOURCE | Mechanical IC.AIRE.ExtraccióPrimari 2
InPort_3781095 | SINK | Mechanical IC.AIRE.ExtraccióPrimari 2
OutPort_3781794 | SOURCE | Mechanical IC.AIRE.ExtraccióPrimari 2
InPort_3781794 | SINK | Mechanical IC.AIRE.ExtraccióPrimari 2
OutPort_3781208 | SOURCE | Mechanical IC.AIRE.ExtraccióPrimari 2
InPort_3781946 | SINK | Mechanical IC.AIRE.ExtraccióPrimari 1
OutPort_3782072 | SOURCE | Mechanical IC.AIRE.ExtraccióPrimari 1
InPort_3782069 | SINK | Mechanical IC.AIRE.ExtraccióPrimari 1
OutPort_3781946 | SOURCE | Mechanical IC.AIRE.ExtraccióPrimari 1
InPort_3782072 | SINK | Mechanical IC.AIRE.ExtraccióPrimari 1
OutPort_3781947 | SOURCE | Mechanical IC.AIRE.ExtraccióPrimari 1
InPort_3782564 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3782823 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3782589 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3782821 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3782823 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3782589 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3782821 | SINK | Mechanical IC.AIRE.Aportació 3
InPort_3782817 | SINK | Mechanical IC.AIRE.Aportació 3
OutPort_3782818 | SOURCE | Mechanical IC.AIRE.Aportació 3
InPort_3782892 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3782992 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3782893 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3782990 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3782992 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3782893 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3782986 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3782987 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3782990 | SINK | Mechanical IC.AIRE.Aportació 5
InPort_3783080 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3783178 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3783081 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3783176 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3783178 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3783081 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3783094 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3783161 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3783161 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3783095 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3783095 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3783159 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3783155 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3783156 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3783159 | SINK | Mechanical IC.AIRE.Aportació 5
InPort_3783172 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3783173 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3783176 | SINK | Mechanical IC.AIRE.Aportació 5
2 x InPort_3783595 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3783622 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3783613 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3783662 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3783679 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3783670 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3783794 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3783681 | SOURCEANDSINK | IF.EXTI.BIEs 5
OutPort_3783785 | SOURCEANDSINK | IF.EXTI.BIEs 5
InPort_3783764 | SOURCEANDSINK | IF.EXTI.BIEs 5
OutPort_3783786 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3783785 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3783789 | SOURCEANDSINK | IF.EXTI.BIEs 5
InPort_3783786 | SOURCEANDSINK | IF.EXTI.BIEs 5

# IfcFlowController: AMB_Comptador_Caleffi_DN15_DN20:AMB.LAM.DN63, AMB_Comptador_Caleffi_DN15_DN20:AMB.LAM.DN63:3703500
In: P0
Type - Classification: 50.10.20.10 Vàlvules i instruments de mesura i control de fluxe de fontaneria (Uniformat); Material: Paint - Caleffi - Black, Paint - Caleffi - Green, Technopolymer - Caleffi - Grey, Metal - Caleffi - Brass
Type - Pset_DuctConnection - ConnectionType: Gas ISO 228/1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Caleffi Italy
Type - Pset_PipeConnection - ConnectionType: Gas ISO 228/1
Type - Pset_ProductRequirements - Category: Pipe Accessories
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.10; 105.AMB.ClassificacioDescripcio: Vàlvules i instruments de mesura i control de fluxe de fontaneria; 109.AMB.CodiTipus: LAM02; 111.AMB.DescripcioTipus: Comptador aigua
Type - 3 AMB.Fabricant - 301.AMB.Fabricant: Caleffi Italy; 302.AMB.Model: 3/4'' Cold sanitary
Type - 5 AMB.Geometria - 501.AMB.Longitud: 33 cm; 502.AMB.Amplada: 7.3 cm; 503.AMB.Altura: 8.2 cm
Material: Metal - Caleffi - Brass, Paint - Caleffi - Green, Paint - Caleffi - Black, Technopolymer - Caleffi - Grey; Group: IF.FONT.AFS 5
Pset_DistributionFlowElementCommon - Reference: AMB_Comptador_Caleffi_DN15_DN20:AMB.LAM.DN63; sets with these values: 2
Pset_DuctConnection - sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Comptador_Caleffi_DN15_DN20: AMB.LAM.DN63; 112.AMB.Servei: Piping System: IF.FONT.AFS; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 20 mmø-20 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.000567098 m3

# IfcFlowController: AMB_Escomesa_PCI:AMB.LAM.EscomesaPCI.DN160, AMB_Escomesa_PCI:AMB.LAM.EscomesaPCI.DN160:3656174
In: P0
Type - Classification: 50.10.20.30 Canalitzacions d'aigua sanitària (Uniformat); Material: <Unnamed> (2)
Type - Pset_ProductRequirements - Category: Pipe Accessories
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.30; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigua sanitària; 109.AMB.CodiTipus: PCI01; 111.AMB.DescripcioTipus: Escomesa aigua xarxa
Type - 5 AMB.Geometria - 501.AMB.Longitud: 7.31242 cm
Pset_DistributionFlowElementCommon - Reference: AMB_Escomesa_PCI:AMB.LAM.EscomesaPCI.DN160; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Escomesa_PCI: AMB.LAM.EscomesaPCI.DN160; 112.AMB.Servei: Piping System: IF.EXTI.BIEs; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 160 mmø
5 AMB.Geometria - 507.AMB.Area: 0.0476378 m2; 509.AMB.Volum: 0.000704631 m3
Group: IF.EXTI.BIEs 5

# IfcFlowController: AMB_Escomesa_aigua:AMB.LAM.EscomesaAigua.DN63, AMB_Escomesa_aigua:AMB.LAM.EscomesaAigua.DN63:3701383
In: P0
Type - Classification: 50.10.20.30 Canalitzacions d'aigua sanitària (Uniformat); Material: <Unnamed> (2)
Type - Pset_ProductRequirements - Category: Pipe Accessories
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.30; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigua sanitària; 109.AMB.CodiTipus: LAM01; 111.AMB.DescripcioTipus: Escomesa aigua xarxa
Type - 5 AMB.Geometria - 501.AMB.Longitud: 7.31242 cm
Pset_DistributionFlowElementCommon - Reference: AMB_Escomesa_aigua:AMB.LAM.EscomesaAigua.DN63; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Escomesa_aigua: AMB.LAM.EscomesaAigua.DN63; 112.AMB.Servei: Piping System: IF.FONT.AFS; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 76 mmø
5 AMB.Geometria - 507.AMB.Area: 0.0124303 m2; 509.AMB.Volum: 0.000150462 m3
Group: IF.FONT.AFS 5

# IfcFlowController: AMB_Escomesa_gas:AMB.LAM.EscomesaGas.DN50, AMB_Escomesa_gas:AMB.LAM.EscomesaGas.DN50:3601143
In: P0
Type - Classification: 50.40.30.10 Canalitzacions de subministrament de combustibles (Uniformat); Material: <Unnamed> (2)
Type - Pset_ProductRequirements - Category: Pipe Accessories
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de subministrament de combustibles; 109.AMB.CodiTipus: GAS01; 111.AMB.DescripcioTipus: Escomesa gas
Type - 5 AMB.Geometria - 501.AMB.Longitud: 7.31242 cm
Pset_DistributionFlowElementCommon - Reference: AMB_Escomesa_gas:AMB.LAM.EscomesaGas.DN50; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Escomesa_gas: AMB.LAM.EscomesaGas.DN50; 112.AMB.Servei: Piping System: IG.Gas; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 63 mmø
5 AMB.Geometria - 507.AMB.Area: 0.00898751 m2; 509.AMB.Volum: 0.000101324 m3
Group: IG.Gas 2

# IfcFlowController: AMB_Vàlvula_Retencio_DN_16-110:AMB.LAM.ValvulaTall.DN75, AMB_Vàlvula_Retencio_DN_16-110:AMB.LAM.ValvulaTall.DN75:3419659
In: P0
Type - Classification: 50.10.20.10 Vàlvules i instruments de mesura i control de fluxe de fontaneria (Uniformat); Material: <Unnamed> (3)
Type - Pset_ProductRequirements - Category: Pipe Accessories
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.10; 105.AMB.ClassificacioDescripcio: Vàlvules i instruments de mesura i control de fluxe de fontaneria; 109.AMB.CodiTipus: LAM10; 111.AMB.DescripcioTipus: Valvula de tall DN75
Type - 5 AMB.Geometria - 501.AMB.Longitud: 10.2394 cm
Pset_DistributionFlowElementCommon - Reference: AMB_Vàlvula_Retencio_DN_16-110:AMB.LAM.ValvulaTall.DN75; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Vàlvula_Retencio_DN_16-110: AMB.LAM.ValvulaTall.DN75; 112.AMB.Servei: Piping System: IF.EXTI.BIEs; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 75 mmø-75 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.000553593 m3
Group: IF.EXTI.BIEs 5

# IfcFlowController: AMB_Vàlvula_Tall_DN_16-110:AMB.GAS.ValvulaTall.DN40 (2)
In: P0
Type - Classification: 50.40.20.10 Vàlvules i instruments de mesura i control de fluxe de combustibles (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Accessories
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.40.20.10; 105.AMB.ClassificacioDescripcio: Vàlvules i instruments de mesura i control de fluxe de combustibles; 109.AMB.CodiTipus: GAS08; 111.AMB.DescripcioTipus: Valvula de tall DN40
Type - 5 AMB.Geometria - 501.AMB.Longitud: 10.2394 cm
Pset_DistributionFlowElementCommon - Reference: AMB_Vàlvula_Tall_DN_16-110:AMB.GAS.ValvulaTall.DN40; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Vàlvula_Tall_DN_16-110: AMB.GAS.ValvulaTall.DN40; 112.AMB.Servei: Piping System: IG.Gas; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 40 mmø-40 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.000238681 m3
Group: IG.Gas 2
Name (AMB_Vàlvula_Tall_DN_16-110:AMB.GAS.ValvulaTall.DN40:...)
3766520
3766691

# IfcFlowController: AMB_Vàlvula_Tall_DN_16-110:AMB.LAM.ValvulaTall.DN20 (11)
Type - Classification: 50.10.20.10 Vàlvules i instruments de mesura i control de fluxe de fontaneria (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Accessories
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.10; 105.AMB.ClassificacioDescripcio: Vàlvules i instruments de mesura i control de fluxe de fontaneria; 109.AMB.CodiTipus: LAM11; 111.AMB.DescripcioTipus: Valvula de tall DN20
Type - 5 AMB.Geometria - 501.AMB.Longitud: 7.31242 cm
Pset_DistributionFlowElementCommon - Reference: AMB_Vàlvula_Tall_DN_16-110:AMB.LAM.ValvulaTall.DN20; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Vàlvula_Tall_DN_16-110: AMB.LAM.ValvulaTall.DN20; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 20 mmø-20 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.0000633039 m3
Name (AMB_Vàlvula_Tall_DN_16-110:AMB.LAM.ValvulaTall.DN20:...) | In | 112.AMB.Servei | 115.AMB.Nivell | Group
3375729 | P0 | Piping System: IF.FONT.AFS | Level: P0 | IF.FONT.AFS 5
3375800 | P0 | Piping System: IF.FONT.ACS | Level: P0 | IF.FONT.ACS 2
3704674 | P0 | Piping System: IF.FONT.ACS | Level: P0 | IF.FONT.ACS 2
3704716 | P0 | Piping System: IF.FONT.AFS | Level: P0 | IF.FONT.AFS 5
3704974 | P0 | Piping System: IF.FONT.AFS | Level: P0 | IF.FONT.AFS 5
3705049 | P0 | Piping System: IF.FONT.ACS | Level: P0 | IF.FONT.ACS 2
3705083 | P0 | Piping System: IF.FONT.AFS | Level: P0 | IF.FONT.AFS 5
3712543 | P1 | Piping System: IF.FONT.AFS | Level: P1 | IF.FONT.AFS 5
3712573 | P1 | Piping System: IF.FONT.ACS | Level: P1 | IF.FONT.ACS 4
3712601 | P1 | Piping System: IF.FONT.ACS | Level: P1 | IF.FONT.ACS 4
3712617 | P1 | Piping System: IF.FONT.AFS | Level: P1 | IF.FONT.AFS 5

# IfcFlowController: AMB_Vàlvula_Tall_DN_16-110:AMB.LAM.ValvulaTall.DN32, AMB_Vàlvula_Tall_DN_16-110:AMB.LAM.ValvulaTall.DN32:3375685
In: P0
Type - Classification: 50.10.20.10 Vàlvules i instruments de mesura i control de fluxe de fontaneria (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Accessories
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.10; 105.AMB.ClassificacioDescripcio: Vàlvules i instruments de mesura i control de fluxe de fontaneria; 109.AMB.CodiTipus: LAM12; 111.AMB.DescripcioTipus: Valvula de tall DN32
Type - 5 AMB.Geometria - 501.AMB.Longitud: 9.7532 cm
Pset_DistributionFlowElementCommon - Reference: AMB_Vàlvula_Tall_DN_16-110:AMB.LAM.ValvulaTall.DN32; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Vàlvula_Tall_DN_16-110: AMB.LAM.ValvulaTall.DN32; 112.AMB.Servei: Piping System: IF.FONT.AFS; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 32 mmø-32 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.000155117 m3
Group: IF.FONT.AFS 5

# IfcFlowController: AMB_Vàlvula_Tall_DN_16-110:AMB.LAM.ValvulaTall.DN40 (2)
In: P1
Type - Classification: 50.10.20.10 Vàlvules i instruments de mesura i control de fluxe de fontaneria (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Accessories
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.10; 105.AMB.ClassificacioDescripcio: Vàlvules i instruments de mesura i control de fluxe de fontaneria; 109.AMB.CodiTipus: LAM13; 111.AMB.DescripcioTipus: Valvula de tall DN40
Type - 5 AMB.Geometria - 501.AMB.Longitud: 10.2394 cm
Pset_DistributionFlowElementCommon - Reference: AMB_Vàlvula_Tall_DN_16-110:AMB.LAM.ValvulaTall.DN40; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Vàlvula_Tall_DN_16-110: AMB.LAM.ValvulaTall.DN40; 115.AMB.Nivell: Level: P1; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 40 mmø-40 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.000238681 m3
Name (AMB_Vàlvula_Tall_DN_16-110:AMB.LAM.ValvulaTall.DN40:...) | 112.AMB.Servei | Group
3619188 | Piping System: IG.Gas | IG.Gas 2
3712655 | Piping System: IF.FONT.AFS | IF.FONT.AFS 5

# IfcFlowController: AMB_Vàlvula_Tall_DN_16-110:AMB.LAM.ValvulaTall.DN50 (3)
In: P0
Type - Classification: 50.10.20.10 Vàlvules i instruments de mesura i control de fluxe de fontaneria (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Accessories
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.10; 105.AMB.ClassificacioDescripcio: Vàlvules i instruments de mesura i control de fluxe de fontaneria; 109.AMB.CodiTipus: LAM15; 111.AMB.DescripcioTipus: Valvula de tall DN75
Type - 5 AMB.Geometria - 501.AMB.Longitud: 10.2394 cm
Pset_DistributionFlowElementCommon - Reference: AMB_Vàlvula_Tall_DN_16-110:AMB.LAM.ValvulaTall.DN50; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Vàlvula_Tall_DN_16-110: AMB.LAM.ValvulaTall.DN50; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 50 mmø-50 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.000354607 m3
Name (AMB_Vàlvula_Tall_DN_16-110:AMB.LAM.ValvulaTall.DN50:...) | 112.AMB.Servei | Group
3563009 | Piping System: IF.EXTI.BIEs | IF.EXTI.BIEs 5
3701535 | Piping System: IF.FONT.AFS | IF.FONT.AFS 5
3701555 | Piping System: IF.FONT.AFS | IF.FONT.AFS 5

# IfcFlowController: AMB_Vàlvula_Tall_DN_16-110:AMB.LAM.ValvulaTall.DN75 (2)
In: P0
Type - Classification: 50.10.20.10 Vàlvules i instruments de mesura i control de fluxe de fontaneria (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Accessories
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.10; 105.AMB.ClassificacioDescripcio: Vàlvules i instruments de mesura i control de fluxe de fontaneria; 109.AMB.CodiTipus: PCI15; 111.AMB.DescripcioTipus: Valvula de tall DN75
Type - 5 AMB.Geometria - 501.AMB.Longitud: 10.2394 cm
Pset_DistributionFlowElementCommon - Reference: AMB_Vàlvula_Tall_DN_16-110:AMB.LAM.ValvulaTall.DN75; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Vàlvula_Tall_DN_16-110: AMB.LAM.ValvulaTall.DN75; 112.AMB.Servei: Piping System: IF.EXTI.BIEs; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 75 mmø-75 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.000774907 m3
Group: IF.EXTI.BIEs 5
Name (AMB_Vàlvula_Tall_DN_16-110:AMB.LAM.ValvulaTall.DN75:...)
3415984
3416065

# IfcFlowFitting: AMB_CLI_Colze:AMB.CLI.Coure.Colze (56)
Type - Classification: 50.30.30.10 Línies frigorífiques (Uniformat); Material: Cobre
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.30.10; 105.AMB.ClassificacioDescripcio: Línies frigorífiques; 109.AMB.CodiTipus: CLI46; 111.AMB.DescripcioTipus: Tuberies coure
Pset_DistributionFlowElementCommon - Reference: AMB_CLI_Colze:AMB.CLI.Coure.Colze; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_CLI_Colze: AMB.CLI.Coure.Colze; 119.AMB.FaseCreacio: Obra
Name (AMB_CLI_Colze:AMB.CLI.Coure.Colze:...) | In | 112.AMB.Servei | 115.AMB.Nivell | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3626847 | P2 | Piping System: IC.REF.Liq | Level: P2 | 15 mmø-15 mmø | 0.00000554141 | IC.REF.Liq 1
3626852 | P2 | Piping System: IC.REF.Gas | Level: P2 | 22 mmø-22 mmø | 0.0000174829 | IC.REF.Gas 2
3626933 | P2 | Piping System: IC.REF.Liq | Level: P2 | 15 mmø-15 mmø | 0.00000554141 | IC.REF.Liq 1
3626935 | P2 | Piping System: IC.REF.Liq | Level: P2 | 15 mmø-15 mmø | 0.00000554141 | IC.REF.Liq 1
3626940 | P2 | Piping System: IC.REF.Gas | Level: P2 | 22 mmø-22 mmø | 0.0000174829 | IC.REF.Gas 2
3626942 | P2 | Piping System: IC.REF.Gas | Level: P2 | 22 mmø-22 mmø | 0.0000174829 | IC.REF.Gas 2
3635849 | P2 | Piping System: IC.REF.Gas | Level: P2 | 32 mmø-32 mmø | 0.0000436395 | IC.REF.Gas 2
3635981 | P2 | Piping System: IC.REF.Gas | Level: P2 | 22 mmø-22 mmø | 0.0000174829 | IC.REF.Gas 2
3635986 | P2 | Piping System: IC.REF.Gas | Level: P2 | 22 mmø-22 mmø | 0.0000174829 | IC.REF.Gas 2
3635990 | P2 | Piping System: IC.REF.Gas | Level: P2 | 22 mmø-22 mmø | 0.0000174829 | IC.REF.Gas 2
3636014 | P2 | Piping System: IC.REF.Liq | Level: P2 | 15 mmø-15 mmø | 0.00000554141 | IC.REF.Liq 1
3636037 | P2 | Piping System: IC.REF.Liq | Level: P2 | 15 mmø-15 mmø | 0.00000554141 | IC.REF.Liq 1
3636041 | P2 | Piping System: IC.REF.Liq | Level: P2 | 15 mmø-15 mmø | 0.00000554141 | IC.REF.Liq 1
3636045 | P2 | Piping System: IC.REF.Liq | Level: P2 | 15 mmø-15 mmø | 0.00000554141 | IC.REF.Liq 1
3636518 | P2 | Piping System: IC.REF.Liq | Level: P2 | 15 mmø-15 mmø | 0.00000554141 | IC.REF.Liq 1
3636543 | P2 | Piping System: IC.REF.Gas | Level: P2 | 22 mmø-22 mmø | 0.0000174829 | IC.REF.Gas 2
3637792 | P0 | Piping System: IC.REF.Liq | Level: P0 | 10 mmø-10 mmø | 0.00000164187 | IC.REF.Liq 1
3637805 | P0 | Piping System: IC.REF.Liq | Level: P0 | 10 mmø-10 mmø | 0.00000164187 | IC.REF.Liq 1
3638276 | P0 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø-15 mmø | 0.00000554141 | IC.REF.Gas 2
3683516 | P2 | Piping System: IC.REF.Gas | Level: P2 | 22 mmø-22 mmø | 0.0000174829 | IC.REF.Gas 2
3683520 | P0 | Piping System: IC.REF.Gas | Level: P0 | 22 mmø-22 mmø | 0.0000174829 | IC.REF.Gas 2
3683526 | P2 | Piping System: IC.REF.Liq | Level: P2 | 15 mmø-15 mmø | 0.00000554141 | IC.REF.Liq 1
3683530 | P0 | Piping System: IC.REF.Liq | Level: P0 | 15 mmø-15 mmø | 0.00000554141 | IC.REF.Liq 1
3690795 | P0 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø-8 mmø | 8.40636e-07 | IC.REF.Liq 1
3690888 | P0 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø-8 mmø | 8.40636e-07 | IC.REF.Liq 1
3690972 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.SANE.Fecal 2
3691000 | P0 | Piping System: IC.REF.Liq | Level: P0 | 10 mmø-10 mmø | 0.00000164187 | IC.REF.Liq 1
3691005 | P0 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø-8 mmø | 8.40636e-07 | IC.REF.Liq 1
3691009 | P0 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø-8 mmø | 8.40636e-07 | IC.REF.Liq 1
3691040 | P0 | Piping System: IC.REF.Gas | Level: P0 | 18 mmø-18 mmø | 0.00000957537 | IC.REF.Gas 2
3691161 | P0 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø-8 mmø | 8.40636e-07 | IC.REF.Liq 1
3691163 | P0 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø-8 mmø | 8.40636e-07 | IC.REF.Liq 1
3691203 | P0 | Piping System: IC.REF.Liq | Level: P0 | 10 mmø-10 mmø | 0.00000164187 | IC.REF.Liq 1
3691207 | P0 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø-8 mmø | 8.40636e-07 | IC.REF.Liq 1
3691211 | P0 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø-8 mmø | 8.40636e-07 | IC.REF.Liq 1
3691233 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.SANE.Fecal 2
3691269 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.SANE.Fecal 2
3691361 | P0 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø-8 mmø | 8.40636e-07 | IC.REF.Liq 1
3691363 | P0 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø-8 mmø | 8.40636e-07 | IC.REF.Liq 1
3691367 | P0 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø-8 mmø | 8.40636e-07 | IC.REF.Liq 1
3691388 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.SANE.Fecal 2
3691445 | P0 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø-8 mmø | 8.40636e-07 | IC.REF.Liq 1
3691447 | P0 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø-8 mmø | 8.40636e-07 | IC.REF.Liq 1
3691451 | P0 | Piping System: IC.REF.Liq | Level: P0 | 10 mmø-10 mmø | 0.00000164187 | IC.REF.Liq 1
3691479 | P0 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø-15 mmø | 0.00000554141 | IC.REF.Gas 2
3691504 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.SANE.Fecal 2
3691788 | P0 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø-15 mmø | 0.00000554141 | IC.REF.Gas 2
3691792 | P0 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø-15 mmø | 0.00000554141 | IC.REF.Gas 2
3691810 | P0 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø-15 mmø | 0.00000554141 | IC.REF.Gas 2
3691814 | P0 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø-15 mmø | 0.00000554141 | IC.REF.Gas 2
3691880 | P0 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø-15 mmø | 0.00000554141 | IC.REF.Gas 2
3691892 | P0 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø-15 mmø | 0.00000554141 | IC.REF.Gas 2
3691896 | P0 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø-15 mmø | 0.00000554141 | IC.REF.Gas 2
