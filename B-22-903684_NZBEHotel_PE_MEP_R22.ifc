Properties of the parts of a building model (IFC2X3), part 4 of 7

# IfcFlowFitting: AMB_CLI_Colze:AMB.CLI.Coure.Colze (56)
Name (AMB_CLI_Colze:AMB.CLI.Coure.Colze:...) | In | 112.AMB.Servei | 115.AMB.Nivell | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3691909 | P0 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø-15 mmø | 0.00000554141 | IC.REF.Gas 2
3691913 | P0 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø-15 mmø | 0.00000554141 | IC.REF.Gas 2
3692081 | P0 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø-15 mmø | 0.00000554141 | IC.REF.Gas 2

# IfcFlowFitting: AMB_CLI_Colze:AMB.LAM.Colze.PEX-A (95)
Type - Classification: 50.10.20.30 Canalitzacions d'aigua sanitària (Uniformat); Material: Plastic.Polyethylene
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.30; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigua sanitària; 109.AMB.CodiTipus: LAM03; 111.AMB.DescripcioTipus: Element de muntatge de tub en Polietilé segons ISO4427 - colze
Pset_DistributionFlowElementCommon - Reference: AMB_CLI_Colze:AMB.LAM.Colze.PEX-A; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_CLI_Colze: AMB.LAM.Colze.PEX-A; 119.AMB.FaseCreacio: Obra
Name (AMB_CLI_Colze:AMB.LAM.Colze.PEX-A:...) | In | 112.AMB.Servei | 115.AMB.Nivell | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3365925 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3365929 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3365940 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3365948 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3366251 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3366260 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3366295 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3366330 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3369590 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3370926 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 25 mmø-25 mmø | 0.0000253527 | IF.FONT.AFS 5
3370963 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3370999 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3371805 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3371809 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3374094 | P0 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 2
3374098 | P0 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 2
3701038 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 32 mmø-32 mmø | 0.0000542154 | IF.FONT.AFS 5
3701069 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 40 mmø-40 mmø | 0.0000827207 | IF.FONT.AFS 5
3701507 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 50 mmø-50 mmø | 0.000156163 | IF.FONT.AFS 5
3703733 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3703743 | P0 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 2
3703776 | P0 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 2
3703778 | P0 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 2
3703780 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3703782 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3703891 | P0 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 2
3704336 | P0 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 2
3704340 | P0 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 2
3704377 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3704381 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3704448 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000113836 | IF.FONT.AFS 5
3704461 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3704463 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3704474 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3704576 | P0 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 2
3704578 | P0 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 2
3704611 | P0 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø-20 mmø | 0.0000113836 | IF.FONT.ACS 2
3704798 | P0 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 2
3704833 | P0 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 2
3704845 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3704882 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3704884 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3704891 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3704893 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3704942 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3704960 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 32 mmø-32 mmø | 0.0000436394 | IF.FONT.AFS 5
3708037 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3708262 | S1 | Piping System: IF.FONT.ACS | Level: S1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 2
3708326 | P0 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 2
3708334 | S1 | Piping System: IF.FONT.ACS | Level: S1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 2
3708336 | S1 | Piping System: IF.FONT.ACS | Level: S1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 2
3708349 | S1 | Piping System: IF.FONT.AFS | Level: S1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3708361 | S1 | Piping System: IF.FONT.AFS | Level: S1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3709551 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3709553 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3709559 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3709565 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3709577 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3709585 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3709593 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3709605 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3709611 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3709615 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 25 mmø-25 mmø | 0.0000253527 | IF.FONT.AFS 5
3709623 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3709635 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3710013 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3710059 | P1 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø-20 mmø | 0.00000941894 | IF.FONT.ACS 4
3710068 | P1 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 4
3710470 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø | 0.00000941894 | IF.FONT.AFS 5
3710487 | P1 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 4
3710495 | P1 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 4
3710497 | P1 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 4
3710520 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3710528 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3710530 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3710822 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3710855 | P1 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 4
3710879 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 25 mmø-25 mmø | 0.0000217292 | IF.FONT.AFS 5
3710934 | P1 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 4
3710936 | P1 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 4
3712312 | P1 | Piping System: IF.FONT.ACS | Level: P1 | 16 mmø-16 mmø | 0.00000672509 | IF.FONT.ACS 4
3712451 | P1 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 4
3712462 | P1 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø-20 mmø | 0.0000130701 | IF.FONT.ACS 4
3712464 | P1 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.ACS 4
3712496 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3712498 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3712502 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 16 mmø-16 mmø | 0.00000672509 | IF.FONT.AFS 5
3712754 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 40 mmø-40 mmø | 0.0000827207 | IF.FONT.AFS 5
3712758 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 40 mmø-40 mmø | 0.0000827207 | IF.FONT.AFS 5
3771944 | S1 | Piping System: IF.FONT.AFS | Level: S1 | 20 mmø-20 mmø | 0.0000114395 | IF.FONT.AFS 5
3775376 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 32 mmø-32 mmø | 0.0000436394 | IF.FONT.AFS 5
3775386 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 32 mmø-32 mmø | 0.0000436394 | IF.FONT.AFS 5
3783610 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 50 mmø-50 mmø | 0.000205258 | IF.FONT.AFS 5
3783622 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 50 mmø-50 mmø | 0.000156163 | IF.FONT.AFS 5
3783642 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 50 mmø-50 mmø | 0.0000596675 | IF.FONT.AFS 5

# IfcFlowFitting: AMB_CLI_Reducció:AMB.CLI.Reduccio (19)
Type - Material: Plastic.Polyethylene
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.30.10; 105.AMB.ClassificacioDescripcio: Línies frigorífiques; 109.AMB.CodiTipus: CLI12; 111.AMB.DescripcioTipus: Accesori tuberies PAP Reduccio
Classification: 50.30.30.10 Línies frigorífiques (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB_CLI_Reducció:AMB.CLI.Reduccio; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_CLI_Reducció: AMB.CLI.Reduccio; 119.AMB.FaseCreacio: Obra
Name (AMB_CLI_Reducció:AMB.CLI.Reduccio:...) | In | 112.AMB.Servei | 115.AMB.Nivell | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3635838 | P2 | Piping System: IC.REF.Gas | Level: P2 | 32 mmø-29 mmø | 0.0000249016 | IC.REF.Gas 2
3635983 | P2 | Piping System: IC.REF.Gas | Level: P2 | 32 mmø-22 mmø | 0.0000223138 | IC.REF.Gas 2
3636039 | P2 | Piping System: IC.REF.Liq | Level: P2 | 19 mmø-15 mmø | 0.00000522954 | IC.REF.Liq 1
3638331 | P0 | Piping System: IC.REF.Gas | Level: P0 | 18 mmø-15 mmø | 0.00000385648 | IC.REF.Gas 2
3638386 | P0 | Piping System: IC.REF.Gas | Level: P0 | 20 mmø-15 mmø | 0.00000436016 | IC.REF.Gas 2
3638547 | P0 | Piping System: IC.REF.Liq | Level: P0 | 10 mmø-8 mmø | 5.9383e-07 | IC.REF.Liq 1
3638665 | P0 | Piping System: IC.REF.Gas | Level: P0 | 20 mmø-15 mmø | 0.00000577711 | IC.REF.Gas 2
3683496 | P0 | Piping System: IC.REF.Liq | Level: P0 | 15 mmø-10 mmø | 0.00000149428 | IC.REF.Liq 1
3683507 | P0 | Piping System: IC.REF.Gas | Level: P0 | 22 mmø-15 mmø | 0.00000490185 | IC.REF.Gas 2
3690521 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 25 mmø-20 mmø | 0.0000124425 | IF.SANE.Fecal 2
3690856 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 25 mmø-20 mmø | 0.0000124425 | IF.SANE.Fecal 2
3690884 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 25 mmø-20 mmø | 0.0000124425 | IF.SANE.Fecal 2
3690914 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 25 mmø-20 mmø | 0.0000124425 | IF.SANE.Fecal 2
3691002 | P0 | Piping System: IC.REF.Liq | Level: P0 | 10 mmø-8 mmø | 7.62528e-07 | IC.REF.Liq 1
3691042 | P0 | Piping System: IC.REF.Gas | Level: P0 | 18 mmø-15 mmø | 0.00000460923 | IC.REF.Gas 2
3691142 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 25 mmø-20 mmø | 0.0000124425 | IF.SANE.Fecal 2
3691167 | P0 | Piping System: IC.REF.Liq | Level: P0 | 10 mmø-8 mmø | 5.9383e-07 | IC.REF.Liq 1
3691205 | P0 | Piping System: IC.REF.Liq | Level: P0 | 10 mmø-8 mmø | 7.62528e-07 | IC.REF.Liq 1
3691453 | P0 | Piping System: IC.REF.Liq | Level: P0 | 10 mmø-8 mmø | 7.62528e-07 | IC.REF.Liq 1

# IfcFlowFitting: AMB_CLI_Reducció:AMB.LAM.Reducció.PEX-A (22)
Type - Material: Plastic.Polyethylene
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.30; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigua sanitària; 109.AMB.CodiTipus: LAM04; 111.AMB.DescripcioTipus: Element de muntatge de tub en Polietilé segons ISO4427 - reducció
Classification: 50.10.20.30 Canalitzacions d'aigua sanitària (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB_CLI_Reducció:AMB.LAM.Reducció.PEX-A; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_CLI_Reducció: AMB.LAM.Reducció.PEX-A; 119.AMB.FaseCreacio: Obra
Name (AMB_CLI_Reducció:AMB.LAM.Reducció.PEX-A:...) | In | 112.AMB.Servei | 115.AMB.Nivell | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3366305 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 25 mmø-20 mmø | 0.0000146447 | IF.FONT.AFS 5
3366327 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 25 mmø-20 mmø | 0.0000147085 | IF.FONT.AFS 5
3370961 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 25 mmø-20 mmø | 0.0000147085 | IF.FONT.AFS 5
3370973 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 32 mmø-25 mmø | 0.0000274954 | IF.FONT.AFS 5
3370996 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 32 mmø-20 mmø | 0.0000231142 | IF.FONT.AFS 5
3371657 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 50 mmø-32 mmø | 0.0000736268 | IF.FONT.AFS 5
3700995 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 50 mmø-40 mmø | 0.0000876802 | IF.FONT.AFS 5
3701036 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 50 mmø-32 mmø | 0.0000736268 | IF.FONT.AFS 5
3703670 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 32 mmø-20 mmø | 0.0000231142 | IF.FONT.AFS 5
3704843 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 32 mmø-20 mmø | 0.0000231142 | IF.FONT.AFS 5
3704962 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 32 mmø-20 mmø | 0.0000231142 | IF.FONT.AFS 5
3709595 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 25 mmø-20 mmø | 0.0000146447 | IF.FONT.AFS 5
3709603 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 25 mmø-20 mmø | 0.0000147085 | IF.FONT.AFS 5
3709621 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 25 mmø-20 mmø | 0.0000147085 | IF.FONT.AFS 5
3709625 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 32 mmø-25 mmø | 0.0000274954 | IF.FONT.AFS 5
3709633 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 32 mmø-20 mmø | 0.0000231142 | IF.FONT.AFS 5
3710824 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 25 mmø-20 mmø | 0.0000146447 | IF.FONT.AFS 5
3710961 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 25 mmø-20 mmø | 0.0000147085 | IF.FONT.AFS 5
3712314 | P1 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø-16 mmø | 0.00000610023 | IF.FONT.ACS 4
3712504 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-16 mmø | 0.00000490416 | IF.FONT.AFS 5
3712723 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 40 mmø-32 mmø | 0.0000509625 | IF.FONT.AFS 5
3712729 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 40 mmø-20 mmø | 0.0000364321 | IF.FONT.AFS 5

# IfcFlowFitting: AMB_CLI_Te:AMB.CLI.Coure (8)
In: P0
Type - Classification: 50.30.30.10 Línies frigorífiques (Uniformat); Material: Cobre
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.30.10; 105.AMB.ClassificacioDescripcio: Línies frigorífiques; 109.AMB.CodiTipus: CLI15; 111.AMB.DescripcioTipus: Te coure
Pset_DistributionFlowElementCommon - Reference: AMB_CLI_Te:AMB.CLI.Coure; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_CLI_Te: AMB.CLI.Coure; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
Name (AMB_CLI_Te:AMB.CLI.Coure:...) | 112.AMB.Servei | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3637848 | Piping System: IC.REF.Liq | 10 mmø-10 mmø-10 mmø | 0.00000112434 | IC.REF.Liq 1
3638012 | Piping System: IC.REF.Liq | 10 mmø-10 mmø-10 mmø | 0.00000112434 | IC.REF.Liq 1
3638024 | Piping System: IC.REF.Liq | 10 mmø-10 mmø-10 mmø | 0.00000112434 | IC.REF.Liq 1
3638035 | Piping System: IC.REF.Liq | 10 mmø-10 mmø-10 mmø | 0.00000112434 | IC.REF.Liq 1
3638314 | Piping System: IC.REF.Gas | 15 mmø-15 mmø-15 mmø | 0.00000379465 | IC.REF.Gas 2
3638718 | Piping System: IC.REF.Gas | 15 mmø-15 mmø-15 mmø | 0.00000379465 | IC.REF.Gas 2
3638722 | Piping System: IC.REF.Gas | 15 mmø-15 mmø-15 mmø | 0.00000379465 | IC.REF.Gas 2
3692077 | Piping System: IC.REF.Gas | 15 mmø-15 mmø-15 mmø | 0.00000379465 | IC.REF.Gas 2

# IfcFlowFitting: AMB_CLI_Te:AMB.LAM.Te.PEX-A (28)
Type - Classification: 50.10.20.30 Canalitzacions d'aigua sanitària (Uniformat); Material: Plastic.Polyethylene
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.30; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigua sanitària; 109.AMB.CodiTipus: LAM05; 111.AMB.DescripcioTipus: Element de muntatge de tub en Polietilé segons ISO4427 - T
Pset_DistributionFlowElementCommon - Reference: AMB_CLI_Te:AMB.LAM.Te.PEX-A; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_CLI_Te: AMB.LAM.Te.PEX-A; 119.AMB.FaseCreacio: Obra
Name (AMB_CLI_Te:AMB.LAM.Te.PEX-A:...) | In | 112.AMB.Servei | 115.AMB.Nivell | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3365936 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø-20 mmø | 0.0000208943 | IF.FONT.AFS 5
3365944 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø-20 mmø | 0.0000208943 | IF.FONT.AFS 5
3366256 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø-20 mmø | 0.0000208943 | IF.FONT.AFS 5
3366291 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø-20 mmø | 0.0000208943 | IF.FONT.AFS 5
3366319 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 25 mmø-25 mmø-25 mmø | 0.0000389684 | IF.FONT.AFS 5
3370952 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 25 mmø-25 mmø-25 mmø | 0.0000177216 | IF.FONT.AFS 5
3370987 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 32 mmø-32 mmø-32 mmø | 0.0000759324 | IF.FONT.AFS 5
3371357 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 50 mmø-50 mmø-50 mmø | 0.000299969 | IF.FONT.AFS 5
3701027 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 50 mmø-50 mmø-50 mmø | 0.000141343 | IF.FONT.AFS 5
3703662 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 32 mmø-32 mmø-32 mmø | 0.0000759324 | IF.FONT.AFS 5
3704470 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø-20 mmø | 0.0000208943 | IF.FONT.AFS 5
3704829 | P0 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø-20 mmø-20 mmø | 0.0000208943 | IF.FONT.ACS 2
3704835 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 32 mmø-32 mmø-32 mmø | 0.0000759324 | IF.FONT.AFS 5
3704921 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø-20 mmø | 0.0000208943 | IF.FONT.AFS 5
3704944 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø-20 mmø | 0.0000208943 | IF.FONT.AFS 5
3707955 | P0 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø-20 mmø-20 mmø | 0.0000208943 | IF.FONT.ACS 2
3708357 | P0 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø-20 mmø-20 mmø | 0.0000208943 | IF.FONT.AFS 5
3709555 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø-20 mmø | 0.0000208943 | IF.FONT.AFS 5
3709561 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø-20 mmø | 0.0000208943 | IF.FONT.AFS 5
3709581 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø-20 mmø | 0.0000208943 | IF.FONT.AFS 5
3709589 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 20 mmø-20 mmø-20 mmø | 0.0000208943 | IF.FONT.AFS 5
3709599 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 25 mmø-25 mmø-25 mmø | 0.0000389684 | IF.FONT.AFS 5
3709617 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 25 mmø-25 mmø-25 mmø | 0.0000177216 | IF.FONT.AFS 5
3709629 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 32 mmø-32 mmø-32 mmø | 0.0000759324 | IF.FONT.AFS 5
3710875 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 25 mmø-25 mmø-25 mmø | 0.0000389684 | IF.FONT.AFS 5
3710953 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 25 mmø-25 mmø-25 mmø | 0.0000177216 | IF.FONT.AFS 5
3711068 | P1 | Piping System: IF.FONT.ACS | Level: P1 | 20 mmø-20 mmø-20 mmø | 0.0000208943 | IF.FONT.ACS 4
3712707 | P1 | Piping System: IF.FONT.AFS | Level: P1 | 40 mmø-40 mmø-40 mmø | 0.000144536 | IF.FONT.AFS 5

# IfcFlowFitting: AMB_Codo_PVC_L2:AMB.SAN.PVC.UNE-EN 1329-1_Serie B (36)
Type - Classification: 50.20.20.20 Canalitzacions d'aigües residuals (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals; 109.AMB.CodiTipus: SAN10; 111.AMB.DescripcioTipus: Codo PVC
Pset_DistributionFlowElementCommon - Reference: AMB_Codo_PVC_L2:AMB.SAN.PVC.UNE-EN 1329-1_Serie B; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Codo_PVC_L2: AMB.SAN.PVC.UNE-EN 1329-1_Serie B; 119.AMB.FaseCreacio: Obra
Name (AMB_Codo_PVC_L2:AMB.SAN.PVC.UNE-EN 1329-1_Serie B:...) | In | 112.AMB.Servei | 115.AMB.Nivell | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3356378 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø-50 mmø | 0.000193474 | IF.SANE.Fecal 3
3356484 | P1 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø-50 mmø | 0.000193474 | IF.SANE.Fecal 7
3356491 | P1 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø-50 mmø | 0.000193474 | IF.SANE.Fecal 7
3356498 | P1 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø-50 mmø | 0.000193474 | IF.SANE.Fecal 3
3356855 | P1 | Piping System: IF.SANE.Fecal | Level: P1 | 110 mmø-110 mmø | 0.00204966 | IF.SANE.Fecal 7
3356983 | P1 | Piping System: IF.SANE.Fecal | Level: P1 | 110 mmø-110 mmø | 0.000941319 | IF.SANE.Fecal 7
3357642 | P1 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø-50 mmø | 0.000193474 | IF.SANE.Fecal 7
3531725 | P2 | Piping System: IF.SANE.Fecal | Level: P2 | 110 mmø-110 mmø | 0.0020496 | IF.SANE.Fecal 7
3531729 | P1 | Piping System: IF.SANE.Fecal | Level: P1 | 110 mmø-110 mmø | 0.0020496 | IF.SANE.Fecal 7
3532300 | P1 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø-50 mmø | 0.000191511 | IF.SANE.Fecal 7
3532670 | P1 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø-50 mmø | 0.000191511 | IF.SANE.Fecal 7
3532958 | P1 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø-50 mmø | 0.000191511 | IF.SANE.Fecal 7
3533090 | P1 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø-50 mmø | 0.000191511 | IF.SANE.Fecal 3
3533226 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 110 mmø-110 mmø | 0.00204966 | IF.SANE.Fecal 7
3533255 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 110 mmø-110 mmø | 0.000941319 | IF.SANE.Fecal 7
3533259 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 110 mmø-110 mmø | 0.00204966 | IF.SANE.Fecal 7
3533276 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø-50 mmø | 0.000193474 | IF.SANE.Fecal 3
3533285 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø-50 mmø | 0.000193474 | IF.SANE.Fecal 3
3533301 | P1 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø-50 mmø | 0.000191511 | IF.SANE.Fecal 3
3533336 | P1 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø-50 mmø | 0.000191511 | IF.SANE.Fecal 3
3533367 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 110 mmø-110 mmø | 0.0020496 | IF.SANE.Fecal 7
3533730 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 50 mmø-50 mmø | 0.000191959 | IF.SANE.Fecal 15
3539790 | P2 | Piping System: IF.SANE.Pluvial | Level: P2 | 90 mmø-90 mmø | 0.00111689 | IF.SANE.Pluvial 11
3540947 | P1 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø-50 mmø | 0.000191511 | IF.SANE.Fecal 3
3540951 | P1 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø-50 mmø | 0.000191511 | IF.SANE.Fecal 15
3543265 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 110 mmø-110 mmø | 0.00203921 | IF.SANE.Fecal 7
3543341 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 110 mmø-110 mmø | 0.00204226 | IF.SANE.Fecal 7
3637485 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø-20 mmø | 0.0000225627 | IF.SANE.Fecal 2
3686051 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø-20 mmø | 0.0000225627 | IF.SANE.Fecal 2
3690981 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø-20 mmø | 0.0000225627 | IF.SANE.Fecal 2
3690983 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø-20 mmø | 0.0000225627 | IF.SANE.Fecal 2
3691512 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø-20 mmø | 0.0000225627 | IF.SANE.Fecal 2
3691514 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø-20 mmø | 0.0000225627 | IF.SANE.Fecal 2
3776205 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø-20 mmø | 0.0000225627 | IF.SANE.Fecal 2
3776279 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø-20 mmø | 0.0000225627 | IF.SANE.Fecal 2
3776322 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø-20 mmø | 0.0000225627 | IF.SANE.Fecal 2

# IfcFlowFitting: AMB_Codo_PVC_L2:UNE-EN 1329-1_Serie B (3)
Type - Classification: 50.20.20.20 Canalitzacions d'aigües residuals (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals
Pset_DistributionFlowElementCommon - Reference: AMB_Codo_PVC_L2:UNE-EN 1329-1_Serie B; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Codo_PVC_L2: UNE-EN 1329-1_Serie B; 112.AMB.Servei: Piping System: IF.SANE.Fecal; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 50 mmø-50 mmø
Group: IF.SANE.Fecal 4
Name (AMB_Codo_PVC_L2:UNE-EN 1329-1_Serie B:...) | In | 115.AMB.Nivell | 509.AMB.Volum (m3)
3770917 | P1 | Level: P1 | 0.000192041
3770925 | P1 | Level: P1 | 0.000191511
3770967 | P0 | Level: P0 | 0.000193474

# IfcFlowFitting: AMB_Colze_Acer-carboni_Soldar:AMB.PCI.Acer.EN 10253-1_3D_Series 2 (3)
In: P0
Type - Classification: 50.50.10.70 BIES (Uniformat); Material: Metal.Steel.Carbon1
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.50.10.70; 105.AMB.ClassificacioDescripcio: BIES; 109.AMB.CodiTipus: PCI11; 111.AMB.DescripcioTipus: Element de muntatge de Tub en acer segons EN10253-1 - colze
Pset_DistributionFlowElementCommon - Reference: AMB_Colze_Acer-carboni_Soldar:AMB.PCI.Acer.EN 10253-1_3D_Series 2; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Colze_Acer-carboni_Soldar: AMB.PCI.Acer.EN 10253-1_3D_Series 2; 112.AMB.Servei: Piping System: IF.EXTI.BIEs; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 50 mmø-50 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.000340892 m3
Group: IF.EXTI.BIEs 5
Name (AMB_Colze_Acer-carboni_Soldar:AMB.PCI.Acer.EN 10253-1_3D_Series 2:...)
3403665
3403667
3403671

# IfcFlowFitting: AMB_Colze_Acer-carboni_Soldar:AMB.PCI.Acer.EN 10253-1_3D_Series 2 (18)
Type - Material: Metal.Steel.Carbon1
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.50.10.70; 105.AMB.ClassificacioDescripcio: BIES; 109.AMB.CodiTipus: PCI11; 111.AMB.DescripcioTipus: Element de muntatge de Tub en acer segons EN10253-1 - colze
Classification: 50.50.10.70 BIES (Uniformat); Group: IF.EXTI.BIEs 5
Pset_DistributionFlowElementCommon - Reference: AMB_Colze_Acer-carboni_Soldar:AMB.PCI.Acer.EN 10253-1_3D_Series 2; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Colze_Acer-carboni_Soldar: AMB.PCI.Acer.EN 10253-1_3D_Series 2; 112.AMB.Servei: Piping System: IF.EXTI.BIEs; 119.AMB.FaseCreacio: Obra
Name (AMB_Colze_Acer-carboni_Soldar:AMB.PCI.Acer.EN 10253-1_3D_Series 2:...) | In | 115.AMB.Nivell | 242.AMB.Mida | 509.AMB.Volum (m3)
3400669 | P0 | Level: P0 | 40 mmø-40 mmø | 0.000164032
3401225 | P0 | Level: P0 | 32 mmø-32 mmø | 0.000106447
3402631 | P0 | Level: P0 | 32 mmø-32 mmø | 0.000106447
3402635 | P1 | Level: P1 | 32 mmø-32 mmø | 0.000106447
3402739 | P1 | Level: P1 | 32 mmø-32 mmø | 0.000106447
3402925 | P1 | Level: P1 | 32 mmø-32 mmø | 0.000106447
3402931 | P0 | Level: P0 | 32 mmø-32 mmø | 0.000106447
3402935 | P1 | Level: P1 | 32 mmø-32 mmø | 0.000106447
3403071 | P1 | Level: P1 | 32 mmø-32 mmø | 0.000106447
3403089 | P1 | Level: P1 | 32 mmø-32 mmø | 0.000106447
3403511 | P1 | Level: P1 | 32 mmø-32 mmø | 0.000106447
3403513 | P1 | Level: P1 | 32 mmø-32 mmø | 0.000106447
3403517 | P0 | Level: P0 | 32 mmø-32 mmø | 0.000106447
3783679 | P0 | Level: P0 | 40 mmø-40 mmø | 0.000164032
3783706 | P0 | Level: P0 | 40 mmø-40 mmø | 0.0000305498
3783764 | P0 | Level: P0 | 32 mmø-32 mmø | 0.000106447
3783768 | P1 | Level: P1 | 32 mmø-32 mmø | 0.000106447
3783794 | P0 | Level: P0 | 40 mmø-40 mmø | 0.000164053

# IfcFlowFitting: AMB_Colze_Acer-inoxidable_Soldar:AMB.CLI.Tuberia.AcerGalvanitzat.Colze (44)
Type - Material: Metal.Steel.Stainless1
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.30.20; 105.AMB.ClassificacioDescripcio: Línies hidràuliques; 109.AMB.CodiTipus: CLI11; 111.AMB.DescripcioTipus: Colze acer galvanitzat
Classification: 50.30.30.20 Línies hidràuliques (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB_Colze_Acer-inoxidable_Soldar:AMB.CLI.Tuberia.AcerGalvanitzat.Colze; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Colze_Acer-inoxidable_Soldar: AMB.CLI.Tuberia.AcerGalvanitzat.Colze; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 20 mmø-20 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.0000258859 m3
Name (AMB_Colze_Acer-inoxidable_Soldar:AMB.CLI.Tuberia.AcerGalvanitzat.Colze:...) | In | 112.AMB.Servei | 115.AMB.Nivell | Group
3672829 | P1 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P1 | IC.AIGUA.Calenta.Retorn 3
3672876 | P1 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P1 | IC.AIGUA.Calenta.Retorn 3
3672950 | P1 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | IC.AIGUA.Calenta.Impulsió 3
3672952 | P1 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P1 | IC.AIGUA.Calenta.Retorn 3
3673191 | P1 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | IC.AIGUA.Calenta.Impulsió 3
3673193 | P1 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | IC.AIGUA.Calenta.Impulsió 3
3673195 | P1 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | IC.AIGUA.Calenta.Impulsió 3
3673235 | P1 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | IC.AIGUA.Calenta.Impulsió 3
3673245 | P1 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | IC.AIGUA.Calenta.Impulsió 3
3673251 | P1 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P1 | IC.AIGUA.Calenta.Retorn 3
3673370 | P1 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | IC.AIGUA.Calenta.Impulsió 3
3673372 | P1 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P1 | IC.AIGUA.Calenta.Retorn 3
3678115 | P1 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P1 | IC.AIGUA.Calenta.Retorn 3
3682196 | P0 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | IC.AIGUA.Calenta.Retorn 3
3682198 | P1 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P1 | IC.AIGUA.Calenta.Retorn 3
3682263 | P1 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | IC.AIGUA.Calenta.Impulsió 3
3682299 | P1 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | IC.AIGUA.Calenta.Impulsió 3
3682301 | P1 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | IC.AIGUA.Calenta.Impulsió 3
3682421 | P0 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | IC.AIGUA.Calenta.Retorn 3
3682427 | P0 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | IC.AIGUA.Calenta.Impulsió 3
3682443 | P1 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | IC.AIGUA.Calenta.Impulsió 3
3682454 | P1 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P1 | IC.AIGUA.Calenta.Retorn 3
3682499 | P0 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | IC.AIGUA.Calenta.Retorn 3
3682573 | P0 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | IC.AIGUA.Calenta.Impulsió 3
3682762 | P0 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | IC.AIGUA.Calenta.Retorn 3
3682803 | P0 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | IC.AIGUA.Calenta.Impulsió 3
3682807 | P0 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | IC.AIGUA.Calenta.Impulsió 3
3682910 | P0 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | IC.AIGUA.Calenta.Retorn 3
3682920 | P0 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | IC.AIGUA.Calenta.Retorn 3
3682928 | P0 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | IC.AIGUA.Calenta.Retorn 3
3682976 | P0 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | IC.AIGUA.Calenta.Impulsió 3
3682986 | P0 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | IC.AIGUA.Calenta.Impulsió 3
3682994 | P0 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | IC.AIGUA.Calenta.Impulsió 3
3683004 | P0 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | IC.AIGUA.Calenta.Impulsió 3
3683039 | P0 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | IC.AIGUA.Calenta.Retorn 3
3683229 | P0 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | IC.AIGUA.Calenta.Retorn 3
3683316 | S1 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: S1 | IC.AIGUA.Calenta.Impulsió 3
3683320 | P0 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | IC.AIGUA.Calenta.Impulsió 3
3683322 | S1 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: S1 | IC.AIGUA.Calenta.Impulsió 3
3683324 | P0 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | IC.AIGUA.Calenta.Retorn 3
3773269 | P0 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | IC.AIGUA.Calenta.Impulsió 3
3773279 | P0 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | IC.AIGUA.Calenta.Impulsió 3
3773303 | P0 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | IC.AIGUA.Calenta.Retorn 3
3773313 | P0 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | IC.AIGUA.Calenta.Retorn 3

# IfcFlowFitting: AMB_Colze_Coure_Socket:AMB.GAS.Coure.ASME B16.22 HH (16)
Type - Material: Metal.Copper
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de subministrament de combustibles; 109.AMB.CodiTipus: GAS03; 111.AMB.DescripcioTipus: Colze coure
Classification: 50.40.30.10 Canalitzacions de subministrament de combustibles (Uniformat); Group: IG.Gas 2
Pset_DistributionFlowElementCommon - Reference: AMB_Colze_Coure_Socket:AMB.GAS.Coure.ASME B16.22 HH; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Colze_Coure_Socket: AMB.GAS.Coure.ASME B16.22 HH; 112.AMB.Servei: Piping System: IG.Gas; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 42 mmø-42 mmø
Name (AMB_Colze_Coure_Socket:AMB.GAS.Coure.ASME B16.22 HH:...) | In | 115.AMB.Nivell | 509.AMB.Volum (m3)
3594763 | P1 | Level: P1 | 0.000269004
3601328 | P2 | Level: P2 | 0.000274914
3601381 | P2 | Level: P2 | 0.00024838
3601385 | P0 | Level: P0 | 0.00024838
3601485 | P2 | Level: P2 | 0.00024838
3601493 | P2 | Level: P2 | 0.000269004
3601495 | P2 | Level: P2 | 0.00024838
3601559 | P2 | Level: P2 | 0.00024838
3611024 | P1 | Level: P1 | 0.00024838
3611049 | P2 | Level: P2 | 0.00024838
3611053 | P1 | Level: P1 | 0.00024838
3619109 | P1 | Level: P1 | 0.00024838
3766304 | P0 | Level: P0 | 0.00024838
3766312 | P0 | Level: P0 | 0.00024838
3766327 | P0 | Level: P0 | 0.00024838
3766338 | P0 | Level: P0 | 0.00024838

# IfcFlowFitting: AMB_Colze_Horizontal_Canal:AMB.COM.ColzeHorizontalCanal (7)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Cable Tray Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.70.30.10; 105.AMB.ClassificacioDescripcio: Safates de distribució per a senyals dèbils; 109.AMB.CodiTipus: COM06; 111.AMB.DescripcioTipus: Safata metàl·lica telecomunicacions reixa amb separadors d'acer per cable electrics - colze
Classification: 50.70.30.10 Safates de distribució per a senyals dèbils (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB_Colze_Horizontal_Canal:AMB.COM.ColzeHorizontalCanal; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Colze_Horizontal_Canal: AMB.COM.ColzeHorizontalCanal; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 503.AMB.Altura: 3 cm; 504.AMB.Gruix: 0.254 cm
Name (AMB_Colze_Horizontal_Canal:AMB.COM.ColzeHorizontalCanal:...) | In | 115.AMB.Nivell | 509.AMB.Volum (m3)
3531426 | P0 | Level: P0 | 0.00167756
3531552 | P0 | Level: P0 | 0.00167756
3531553 | P0 | Level: P0 | 0.000486159
3531565 | P1 | Level: P1 | 0.00167756
3531568 | P1 | Level: P1 | 0.00167756
3531569 | P1 | Level: P1 | 0.000486159
3747122 | P0 | Level: P0 | 0.00167756

# IfcFlowFitting: AMB_Colze_Socket:AMB.SAN.PVC_HH (39)
In: P0
Type - Classification: 50.20.20.20 Canalitzacions d'aigües residuals (Uniformat); Material: Plastic.PVC·U
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals; 109.AMB.CodiTipus: SAN08; 111.AMB.DescripcioTipus: Element de muntatge de tub en PVC
Pset_DistributionFlowElementCommon - Reference: AMB_Colze_Socket:AMB.SAN.PVC_HH; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Colze_Socket: AMB.SAN.PVC_HH; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
Name (AMB_Colze_Socket:AMB.SAN.PVC_HH:...) | 112.AMB.Servei | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3535628 | Piping System: IF.SANE.Pluvial | 125 mmø-125 mmø | 0.0074079 | IF.SANE.Pluvial 6
3535705 | Piping System: IF.SANE.Pluvial | 160 mmø-160 mmø | 0.00192754 | IF.SANE.Pluvial 6
3535798 | Piping System: IF.SANE.Pluvial | 125 mmø-125 mmø | 0.00096667 | IF.SANE.Pluvial 6
3536945 | Piping System: IF.SANE.Pluvial | 160 mmø-160 mmø | 0.00192754 | IF.SANE.Pluvial 11
3536961 | Piping System: IF.SANE.Pluvial | 160 mmø-160 mmø | 0.00192754 | IF.SANE.Pluvial 11
3537091 | Piping System: IF.SANE.Pluvial | 125 mmø-125 mmø | 0.00730183 | IF.SANE.Pluvial 11
3537396 | Piping System: IF.SANE.Pluvial | 160 mmø-160 mmø | 0.0150017 | IF.SANE.Pluvial 6
3538286 | Piping System: IF.SANE.Pluvial | 125 mmø-125 mmø | 0.000966676 | IF.SANE.Pluvial 5
3539412 | Piping System: IF.SANE.Pluvial | 125 mmø-125 mmø | 0.00737848 | IF.SANE.Pluvial 5
3539758 | Piping System: IF.SANE.Pluvial | 90 mmø-90 mmø | 0.00245894 | IF.SANE.Pluvial 6
3539767 | Piping System: IF.SANE.Pluvial | 90 mmø-90 mmø | 0.00245894 | IF.SANE.Pluvial 6
3539774 | Piping System: IF.SANE.Pluvial | 90 mmø-90 mmø | 0.00245894 | IF.SANE.Pluvial 6
3539796 | Piping System: IF.SANE.Pluvial | 125 mmø-125 mmø | 0.00730183 | IF.SANE.Pluvial 11
3539817 | Piping System: IF.SANE.Pluvial | 90 mmø-90 mmø | 0.00245894 | IF.SANE.Pluvial 11
3539821 | Piping System: IF.SANE.Pluvial | 90 mmø-90 mmø | 0.00245894 | IF.SANE.Pluvial 5
3539861 | Piping System: IF.SANE.Pluvial | 90 mmø-90 mmø | 0.00245894 | IF.SANE.Pluvial 11
3539901 | Piping System: IF.SANE.Pluvial | 125 mmø-125 mmø | 0.00725315 | IF.SANE.Pluvial 5
3540187 | Piping System: IF.SANE.Pluvial | 90 mmø-90 mmø | 0.00245894 | IF.SANE.Pluvial 5
3540289 | Piping System: IF.SANE.Pluvial | 90 mmø-90 mmø | 0.00245894 | IF.SANE.Pluvial 5
3540645 | Piping System: IF.SANE.Pluvial | 90 mmø-90 mmø | 0.00245894 | IF.SANE.Pluvial 7
3540672 | Piping System: IF.SANE.Fecal | 160 mmø-160 mmø | 0.0144152 | IF.SANE.Fecal 1
3543490 | Piping System: IF.SANE.Fecal | 160 mmø-160 mmø | 0.0150056 | IF.SANE.Fecal 1
3543616 | Piping System: IF.SANE.Pluvial | 125 mmø-125 mmø | 0.00742119 | IF.SANE.Pluvial 3
3543714 | Piping System: IF.SANE.Pluvial | 125 mmø-125 mmø | 0.000966673 | IF.SANE.Pluvial 3
3543835 | Piping System: IF.SANE.Pluvial | 90 mmø-90 mmø | 0.00245896 | IF.SANE.Pluvial 3
3543871 | Piping System: IF.SANE.Pluvial | 90 mmø-90 mmø | 0.00245894 | IF.SANE.Pluvial 3
3544069 | Piping System: IF.SANE.Pluvial | 90 mmø-90 mmø | 0.00245747 | IF.SANE.Pluvial 3
3544186 | Piping System: IF.SANE.Pluvial | 90 mmø-90 mmø | 0.00245986 | IF.SANE.Pluvial 5
3770869 | Piping System: IF.SANE.Fecal | 125 mmø-125 mmø | 0.00737294 | IF.SANE.Fecal 4
3770873 | Piping System: IF.SANE.Fecal | 125 mmø-125 mmø | 0.00727697 | IF.SANE.Fecal 4
3770901 | Piping System: IF.SANE.Fecal | 50 mmø-50 mmø | 0.000472567 | IF.SANE.Fecal 4
3770927 | Piping System: IF.SANE.Fecal | 50 mmø-50 mmø | 0.000421629 | IF.SANE.Fecal 4
3770931 | Piping System: IF.SANE.Fecal | 50 mmø-50 mmø | 0.000421629 | IF.SANE.Fecal 4
3770935 | Piping System: IF.SANE.Fecal | 50 mmø-50 mmø | 0.000421629 | IF.SANE.Fecal 4
3770939 | Piping System: IF.SANE.Fecal | 50 mmø-50 mmø | 0.000421629 | IF.SANE.Fecal 4
3770941 | Piping System: IF.SANE.Fecal | 110 mmø-110 mmø | 0.00448951 | IF.SANE.Fecal 4
3770953 | Piping System: IF.SANE.Fecal | 50 mmø-50 mmø | 0.0000642231 | IF.SANE.Fecal 4
3770963 | Piping System: IF.SANE.Fecal | 50 mmø-50 mmø | 0.000421531 | IF.SANE.Fecal 4
3770965 | Piping System: IF.SANE.Fecal | 50 mmø-50 mmø | 0.000421624 | IF.SANE.Fecal 4

# IfcFlowFitting: AMB_Colze_Vertical_Exterior_Canal:AMB.COM.ColzeVerticalExteriorlCanal, AMB_Colze_Vertical_Exterior_Canal:AMB.COM.ColzeVerticalExteriorlCanal:3747119
In: P0
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Cable Tray Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.70.30.10; 105.AMB.ClassificacioDescripcio: Safates de distribució per a senyals dèbils; 109.AMB.CodiTipus: COM07; 111.AMB.DescripcioTipus: Safata metàl·lica telecomunicacions reixa amb separadors d'acer per cable electrics - colze exteriò
Classification: 50.70.30.10 Safates de distribució per a senyals dèbils (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB_Colze_Vertical_Exterior_Canal:AMB.COM.ColzeVerticalExteriorlCanal; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Colze_Vertical_Exterior_Canal: AMB.COM.ColzeVerticalExteriorlCanal; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 503.AMB.Altura: 15 cm; 504.AMB.Gruix: 0.254 cm; 509.AMB.Volum: 0.00123021 m3

# IfcFlowFitting: AMB_Colze_Xapa_Circular:AMB.CLI.ConducteXapa.Colze (9)
Type - Classification: 50.30.40.20 Extracció de aire primari (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Duct Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.20; 105.AMB.ClassificacioDescripcio: Extracció de aire primari; 109.AMB.CodiTipus: CLI16; 111.AMB.DescripcioTipus: Conducte xapa circular
Pset_DistributionFlowElementCommon - Reference: AMB_Colze_Xapa_Circular:AMB.CLI.ConducteXapa.Colze; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Colze_Xapa_Circular: AMB.CLI.ConducteXapa.Colze; 112.AMB.Servei: Duct System: IC.AIRE.Extracció.Serveis; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 100 mmø-100 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.00139074 m3
Name (AMB_Colze_Xapa_Circular:AMB.CLI.ConducteXapa.Colze:...) | In | 115.AMB.Nivell | Group
3480434 | P0 | Level: P0 | Mechanical IC.AIRE.Extracció.Serveis 3
3480539 | P0 | Level: P0 | Mechanical IC.AIRE.Extracció.Serveis 2
3480541 | P0 | Level: P0 | Mechanical IC.AIRE.Extracció.Serveis 2
3484245 | P0 | Level: P0 | Mechanical IC.AIRE.Extracció.Serveis 3
3484691 | P0 | Level: P0 | Mechanical IC.AIRE.Extracció.Serveis 3
3657980 | P1 | Level: P1 | Mechanical IC.AIRE.Extracció.Serveis 6
3658135 | P1 | Level: P1 | Mechanical IC.AIRE.Extracció.Serveis 6
3658146 | P1 | Level: P1 | Mechanical IC.AIRE.Extracció.Serveis 6
3658412 | P1 | Level: P1 | Mechanical IC.AIRE.Extracció.Serveis 6

# IfcFlowFitting: AMB_Colze_Xapa_Circular:AMB.CLI.ConducteXapa.Colze (4)
In: P0
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Duct Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.20; 105.AMB.ClassificacioDescripcio: Extracció de aire primari; 109.AMB.CodiTipus: CLI16; 111.AMB.DescripcioTipus: Conducte xapa circular
Classification: 50.30.40.20 Extracció de aire primari (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB_Colze_Xapa_Circular:AMB.CLI.ConducteXapa.Colze; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Colze_Xapa_Circular: AMB.CLI.ConducteXapa.Colze; 112.AMB.Servei: Duct System: IC.AIRE.Extracció.Serveis; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
Name (AMB_Colze_Xapa_Circular:AMB.CLI.ConducteXapa.Colze:...) | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3480348 | 125 mmø-125 mmø | 0.00265493 | Mechanical IC.AIRE.Extracció.Serveis 1
3484511 | 125 mmø-125 mmø | 0.00265493 | Mechanical IC.AIRE.Extracció.Serveis 1
3484978 | 100 mmø-100 mmø | 0.000362679 | Mechanical IC.AIRE.Extracció.Serveis 4
3484980 | 100 mmø-100 mmø | 0.00118512 | Mechanical IC.AIRE.Extracció.Serveis 4

# IfcFlowFitting: AMB_Colze_Xapa_Rectangular:AMB.CLI.ConducteXapa.Colze.Rectangular.Retorn (12)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Duct Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.40; 105.AMB.ClassificacioDescripcio: Retorn de aire tractat; 109.AMB.CodiTipus: CLI48; 111.AMB.DescripcioTipus: Conducte Xapa colze. Rectangular. Retorn
Classification: 50.30.40.40 Retorn de aire tractat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB_Colze_Xapa_Rectangular:AMB.CLI.ConducteXapa.Colze.Rectangular.Retorn; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Colze_Xapa_Rectangular: AMB.CLI.ConducteXapa.Colze.Rectangular.Retorn; 112.AMB.Servei: Duct System: IC.AIRE.Aportació; 119.AMB.FaseCreacio: Obra
Name (AMB_Colze_Xapa_Rectangular:AMB.CLI.ConducteXapa.Colze.Rectangular.Retorn:...) | In | 115.AMB.Nivell | 242.AMB.Mida | 503.AMB.Altura (cm) | 509.AMB.Volum (m3) | Group
3447665 | P0 | Level: P0 | 350 mmx300 mm-350 mmx300 mm | 30 | 0.0537566 | Mechanical IC.AIRE.Aportació 5
3447666 | P0 | Level: P0 | 350 mmx300 mm-350 mmx300 mm | 30 | 0.0537566 | Mechanical IC.AIRE.Aportació 5
3448491 | P0 | Level: P0 | 400 mmx150 mm-400 mmx150 mm | 15 | 0.0330742 | Mechanical IC.AIRE.Aportació 5
3462928 | P0 | Level: P0 | 900 mmx250 mm-900 mmx250 mm | 25 | 0.213101 | Mechanical IC.AIRE.Aportació 4
3464191 | P0 | Level: P0 | 650 mmx250 mm-650 mmx250 mm | 25 | 0.0445725 | Mechanical IC.AIRE.Aportació 5
3464208 | P0 | Level: P0 | 250 mmx250 mm-250 mmx250 mm | 25 | 0.0204458 | Mechanical IC.AIRE.Aportació 5
3697056 | P1 | Level: P1 | 275 mmx150 mm-275 mmx150 mm | 15 | 0.0186888 | Mechanical IC.AIRE.Aportació 3
3697070 | P1 | Level: P1 | 900 mmx250 mm-900 mmx250 mm | 25 | 0.213101 | Mechanical IC.AIRE.Aportació 2
3698046 | P1 | Level: P1 | 500 mmx250 mm-500 mmx250 mm | 25 | 0.0787599 | Mechanical IC.AIRE.Aportació 3
3698214 | P1 | Level: P1 | 400 mmx250 mm-400 mmx250 mm | 25 | 0.0551237 | Mechanical IC.AIRE.Aportació 3
3698792 | P1 | Level: P1 | 400 mmx250 mm-400 mmx250 mm | 25 | 0.0551237 | Mechanical IC.AIRE.Aportació 3
3778196 | P1 | Level: P1 | 500 mmx250 mm-500 mmx250 mm | 25 | 0.0587595 | Mechanical IC.AIRE.Aportació 3

# IfcFlowFitting: AMB_Empelt_Xapa_Circular:AMB.CLI.ConducteXapa.Empelt (5)
Type - Material: <Unnamed> (2)
Type - Pset_ProductRequirements - Category: Duct Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.20; 105.AMB.ClassificacioDescripcio: Extracció de aire primari; 109.AMB.CodiTipus: CLI22; 111.AMB.DescripcioTipus: Conducte xapa circular. Empelt
Classification: 50.30.40.20 Extracció de aire primari (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB_Empelt_Xapa_Circular:AMB.CLI.ConducteXapa.Empelt; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Empelt_Xapa_Circular: AMB.CLI.ConducteXapa.Empelt; 112.AMB.Servei: Duct System: IC.AIRE.Extracció.Serveis; 119.AMB.FaseCreacio: Obra
Name (AMB_Empelt_Xapa_Circular:AMB.CLI.ConducteXapa.Empelt:...) | In | 115.AMB.Nivell | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3695573 | P1 | Level: P1 | 100 mmø-100 mmø | 0.000989839 | Mechanical IC.AIRE.Extracció.Serveis 9
3776788 | P0 | Level: P0 | 100 mmø-100 mmø | 0.000989839 | Mechanical IC.AIRE.Extracció.Serveis 11 | Material: <Unnamed>
3780260 | P0 | Level: P0 | 100 mmø-90 mmø | 0.000854349 | Mechanical IC.AIRE.Extracció 1; Mechanical IC.AIRE.Extracció.Serveis 4
3780594 | S1 | Level: S1 | 100 mmø-90 mmø | 0.000854349 | Mechanical IC.AIRE.Extracció.Serveis 4 | Material: <Unnamed>
3780864 | P0 | Level: P0 | 100 mmø-90 mmø | 0.000763067 | Mechanical IC.AIRE.Extracció.Serveis 1

# IfcFlowFitting: AMB_Empelt_Xapa_Rectangular:Estándar (2)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: AMB_Empelt_Xapa_Rectangular:Estándar; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Empelt_Xapa_Rectangular: Estándar; 112.AMB.Servei: Duct System: IC.AIRE.ExtraccióPrimari; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 900 mmx250 mm-900 mmx250 mm
5 AMB.Geometria - 503.AMB.Altura: 25 cm; 509.AMB.Volum: 0.005625 m3
Name (AMB_Empelt_Xapa_Rectangular:Estándar:...) | In | 115.AMB.Nivell | Group
3781629 | P0 | Level: P0 | Mechanical IC.AIRE.ExtraccióPrimari 2
3782069 | P1 | Level: P1 | Mechanical IC.AIRE.ExtraccióPrimari 1

# IfcFlowFitting: AMB_Injerto_PVC_L2:AMB.SAN.PVC.UNE-EN 1329-1_Serie B (2)
In: P1
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals; 109.AMB.CodiTipus: SAN09; 111.AMB.DescripcioTipus: Injerto PVC
Classification: 50.20.20.20 Canalitzacions d'aigües residuals (Uniformat); Group: IF.SANE.Fecal 7
Pset_DistributionFlowElementCommon - Reference: AMB_Injerto_PVC_L2:AMB.SAN.PVC.UNE-EN 1329-1_Serie B; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Injerto_PVC_L2: AMB.SAN.PVC.UNE-EN 1329-1_Serie B; 112.AMB.Servei: Piping System: IF.SANE.Fecal; 115.AMB.Nivell: Level: P1; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 110 mmø-110 mmø
Name (AMB_Injerto_PVC_L2:AMB.SAN.PVC.UNE-EN 1329-1_Serie B:...) | 509.AMB.Volum (m3)
3356979 | 0.00163474
3357061 | 0.00132524

# IfcFlowFitting: AMB_PE_Colze:AMB.LAM.Colze.PEAD_PN25 (7)
In: P0
Type - Classification: 50.10.20.30 Canalitzacions d'aigua sanitària (Uniformat); Material: AMB.Plàstic.PolietilèBaixaDensitat.PEBD
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.30; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigua sanitària; 109.AMB.CodiTipus: LAM09; 111.AMB.DescripcioTipus: Accesori tuberies PEAD_PN25 Colze
Pset_DistributionFlowElementCommon - Reference: AMB_PE_Colze:AMB.LAM.Colze.PEAD_PN25; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_PE_Colze: AMB.LAM.Colze.PEAD_PN25; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
Name (AMB_PE_Colze:AMB.LAM.Colze.PEAD_PN25:...) | NominalDiameter | 112.AMB.Servei | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3403743 | 7.5 | Piping System: IF.EXTI.BIEs | 75 mmø-75 mmø | 0.000928918 | IF.EXTI.BIEs 5
3403758 | 7.5 | Piping System: IF.EXTI.BIEs | 75 mmø-75 mmø | 0.000928918 | IF.EXTI.BIEs 5
3403812 | 7.5 | Piping System: IF.EXTI.BIEs | 75 mmø-75 mmø | 0.000928918 | IF.EXTI.BIEs 5
3701176 | 6.3 | Piping System: IF.FONT.AFS | 63 mmø-63 mmø | 0.000596823 | IF.FONT.AFS 5
3701189 | 6.3 | Piping System: IF.FONT.AFS | 63 mmø-63 mmø | 0.000596855 | IF.FONT.AFS 5
3701400 | 6.3 | Piping System: IF.FONT.AFS | 63 mmø-63 mmø | 0.000596855 | IF.FONT.AFS 5
3701497 | 5 | Piping System: IF.FONT.AFS | 50 mmø-50 mmø | 0.000313377 | IF.FONT.AFS 5

# IfcFlowFitting: AMB_PE_Reduccio:AMB.LAM.Reduccio.PEAD_PN25 (8)
In: P0
Type - Classification: 50.10.20.30 Canalitzacions d'aigua sanitària (Uniformat); Material: AMB.Plàstic.PolietilèAltaDensitat.PEAD
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.30; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigua sanitària; 109.AMB.CodiTipus: LAM08; 111.AMB.DescripcioTipus: Accesori tuberies PEAD_PN25 Reducció
Pset_DistributionFlowElementCommon - Reference: AMB_PE_Reduccio:AMB.LAM.Reduccio.PEAD_PN25; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_PE_Reduccio: AMB.LAM.Reduccio.PEAD_PN25; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
Name (AMB_PE_Reduccio:AMB.LAM.Reduccio.PEAD_PN25:...) | 112.AMB.Servei | 242.AMB.Mida | 501.AMB.Longitud (cm) | 507.AMB.Area (m2) | 509.AMB.Volum (m3) | Group
3403814 | Piping System: IF.EXTI.BIEs | 75 mmø-50 mmø | 10.055 | 0.0219641 | 0.000483432 | IF.EXTI.BIEs 5
3701499 | Piping System: IF.FONT.AFS | 63 mmø-50 mmø | 9.467 | 0.0184596 | 0.000353047 | IF.FONT.AFS 5
3701541 | Piping System: IF.FONT.AFS | 63 mmø-50 mmø | 9.467 | 0.0184596 | 0.000353047 | IF.FONT.AFS 5
3701543 | Piping System: IF.FONT.AFS | 63 mmø-50 mmø | 9.467 | 0.0184596 | 0.000353047 | IF.FONT.AFS 5
3701559 | Piping System: IF.FONT.AFS | 63 mmø-50 mmø | 9.467 | 0.0184596 | 0.000353047 | IF.FONT.AFS 5
3701561 | Piping System: IF.FONT.AFS | 63 mmø-50 mmø | 9.467 | 0.0184596 | 0.000353047 | IF.FONT.AFS 5
3703504 | Piping System: IF.FONT.AFS | 63 mmø-20 mmø | 7.127 | 0.0105442 | 0.000207257 | IF.FONT.AFS 5
3703507 | Piping System: IF.FONT.AFS | 63 mmø-20 mmø | 7.127 | 0.0105442 | 0.000207257 | IF.FONT.AFS 5

# IfcFlowFitting: AMB_Reducció_Acer-carboni_Soldar:AMB.PCI.Acer.EN 10253-1_Series 2 (6)
In: P0
Type - Material: Metal.Steel.Carbon1
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.50.10.70; 105.AMB.ClassificacioDescripcio: BIES; 109.AMB.CodiTipus: PCI12; 111.AMB.DescripcioTipus: Element de muntatge de Tub en acer segons EN10253-1 - Reducció
Classification: 50.50.10.70 BIES (Uniformat); Group: IF.EXTI.BIEs 5
Pset_DistributionFlowElementCommon - Reference: AMB_Reducció_Acer-carboni_Soldar:AMB.PCI.Acer.EN 10253-1_Series 2; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Reducció_Acer-carboni_Soldar: AMB.PCI.Acer.EN 10253-1_Series 2; 112.AMB.Servei: Piping System: IF.EXTI.BIEs; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
Name (AMB_Reducció_Acer-carboni_Soldar:AMB.PCI.Acer.EN 10253-1_Series 2:...) | 242.AMB.Mida | 509.AMB.Volum (m3)
3402736 | 40 mmø-32 mmø | 0.000103356
3402881 | 40 mmø-32 mmø | 0.000103356
3403585 | 50 mmø-40 mmø | 0.000176404
3783708 | 50 mmø-40 mmø | 0.000176514
3783789 | 40 mmø-32 mmø | 0.000103356
3783792 | 40 mmø-32 mmø | 0.000103356

# IfcFlowFitting: AMB_Reducció_Coure_Socket:AMB.GAS.Coure.Reducció.ASME B16.22_HH (7)
Type - Material: Metal.Copper
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de subministrament de combustibles; 109.AMB.CodiTipus: GAS04; 111.AMB.DescripcioTipus: Reducció coure
Classification: 50.40.30.10 Canalitzacions de subministrament de combustibles (Uniformat); Group: IG.Gas 2
Pset_DistributionFlowElementCommon - Reference: AMB_Reducció_Coure_Socket:AMB.GAS.Coure.Reducció.ASME B16.22_HH; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Reducció_Coure_Socket: AMB.GAS.Coure.Reducció.ASME B16.22_HH; 112.AMB.Servei: Piping System: IG.Gas; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 42 mmø-40 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.0000670085 m3
Name (AMB_Reducció_Coure_Socket:AMB.GAS.Coure.Reducció.ASME B16.22_HH:...) | In | 115.AMB.Nivell
3619111 | P1 | Level: P1
3619192 | P1 | Level: P1
3619194 | P1 | Level: P1
3766524 | P0 | Level: P0
3766526 | P0 | Level: P0
3766695 | P0 | Level: P0
3766697 | P0 | Level: P0

# IfcFlowFitting: AMB_Reducció_Socket:AMB.SAN.PVC.Reduccio.UNE EN 1329-1 (29)
In: P0
Type - Classification: 50.20.20.20 Canalitzacions d'aigües residuals (Uniformat); Material: Plastic.PVC·U
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals; 109.AMB.CodiTipus: SAN13; 111.AMB.DescripcioTipus: Accesori tuberies PVC segons UNE EN 1329-1 - Reducció
Pset_DistributionFlowElementCommon - Reference: AMB_Reducció_Socket:AMB.SAN.PVC.Reduccio.UNE EN 1329-1; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Reducció_Socket: AMB.SAN.PVC.Reduccio.UNE EN 1329-1; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
Name (AMB_Reducció_Socket:AMB.SAN.PVC.Reduccio.UNE EN 1329-1:...) | 112.AMB.Servei | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3536913 | Piping System: IF.SANE.Pluvial | 160 mmø-125 mmø | 0.00288439 | IF.SANE.Pluvial 6
3537051 | Piping System: IF.SANE.Pluvial | 160 mmø-125 mmø | 0.00288439 | IF.SANE.Pluvial 11
3537363 | Piping System: IF.SANE.Pluvial | 160 mmø-125 mmø | 0.00288439 | IF.SANE.Pluvial 6
3538137 | Piping System: IF.SANE.Pluvial | 160 mmø-125 mmø | 0.00288439 | IF.SANE.Pluvial 11
3539404 | Piping System: IF.SANE.Pluvial | 160 mmø-125 mmø | 0.00288439 | IF.SANE.Pluvial 5
3539589 | Piping System: IF.SANE.Pluvial | 160 mmø-125 mmø | 0.00288439 | IF.SANE.Pluvial 5
3539761 | Piping System: IF.SANE.Pluvial | 125 mmø-90 mmø | 0.00138452 | IF.SANE.Pluvial 6
3539769 | Piping System: IF.SANE.Pluvial | 160 mmø-90 mmø | 0.00243744 | IF.SANE.Pluvial 6
3539776 | Piping System: IF.SANE.Pluvial | 125 mmø-90 mmø | 0.00138452 | IF.SANE.Pluvial 6
3539819 | Piping System: IF.SANE.Pluvial | 160 mmø-90 mmø | 0.00243744 | IF.SANE.Pluvial 11
3539823 | Piping System: IF.SANE.Pluvial | 125 mmø-90 mmø | 0.00138452 | IF.SANE.Pluvial 5
3539863 | Piping System: IF.SANE.Pluvial | 125 mmø-90 mmø | 0.00138452 | IF.SANE.Pluvial 11
3540189 | Piping System: IF.SANE.Pluvial | 125 mmø-90 mmø | 0.00138452 | IF.SANE.Pluvial 5
3540279 | Piping System: IF.SANE.Pluvial | 160 mmø-125 mmø | 0.00288439 | IF.SANE.Pluvial 5
3540291 | Piping System: IF.SANE.Pluvial | 125 mmø-90 mmø | 0.00138452 | IF.SANE.Pluvial 5
3540647 | Piping System: IF.SANE.Pluvial | 125 mmø-90 mmø | 0.000996888 | IF.SANE.Pluvial 7
3543686 | Piping System: IF.SANE.Pluvial | 160 mmø-125 mmø | 0.00288439 | IF.SANE.Pluvial 3
3543838 | Piping System: IF.SANE.Pluvial | 125 mmø-90 mmø | 0.00138452 | IF.SANE.Pluvial 3
3543869 | Piping System: IF.SANE.Pluvial | 160 mmø-125 mmø | 0.00288439 | IF.SANE.Pluvial 3
