Properties of the parts of a building model (IFC2X3), part 5 of 7

# IfcFlowFitting: AMB_Reducció_Socket:AMB.SAN.PVC.Reduccio.UNE EN 1329-1 (29)
Name (AMB_Reducció_Socket:AMB.SAN.PVC.Reduccio.UNE EN 1329-1:...) | 112.AMB.Servei | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3543873 | Piping System: IF.SANE.Pluvial | 125 mmø-90 mmø | 0.00138452 | IF.SANE.Pluvial 3
3544072 | Piping System: IF.SANE.Pluvial | 125 mmø-90 mmø | 0.00138452 | IF.SANE.Pluvial 3
3544189 | Piping System: IF.SANE.Pluvial | 125 mmø-90 mmø | 0.00138452 | IF.SANE.Pluvial 5
3770881 | Piping System: IF.SANE.Fecal | 125 mmø-50 mmø | 0.000964787 | IF.SANE.Fecal 4
3770889 | Piping System: IF.SANE.Fecal | 125 mmø-50 mmø | 0.000964787 | IF.SANE.Fecal 4
3770895 | Piping System: IF.SANE.Fecal | 125 mmø-50 mmø | 0.000964787 | IF.SANE.Fecal 4
3770907 | Piping System: IF.SANE.Fecal | 125 mmø-110 mmø | 0.0016065 | IF.SANE.Fecal 4
3770919 | Piping System: IF.SANE.Fecal | 125 mmø-50 mmø | 0.000385903 | IF.SANE.Fecal 4
3770949 | Piping System: IF.SANE.Fecal | 110 mmø-50 mmø | 0.000909767 | IF.SANE.Fecal 4
3770961 | Piping System: IF.SANE.Fecal | 125 mmø-50 mmø | 0.000964787 | IF.SANE.Fecal 4

# IfcFlowFitting: AMB_Reducció_Xapa_Circular:AMB.CLI.ConducteHelicoidal.Reduccio (16)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Duct Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.20; 105.AMB.ClassificacioDescripcio: Extracció de aire primari; 109.AMB.CodiTipus: CLI27; 111.AMB.DescripcioTipus: Conducte xapa circular.Reducció
Classification: 50.30.40.20 Extracció de aire primari (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB_Reducció_Xapa_Circular:AMB.CLI.ConducteHelicoidal.Reduccio; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Reducció_Xapa_Circular: AMB.CLI.ConducteHelicoidal.Reduccio; 112.AMB.Servei: Duct System: IC.AIRE.Extracció.Serveis; 119.AMB.FaseCreacio: Obra
Name (AMB_Reducció_Xapa_Circular:AMB.CLI.ConducteHelicoidal.Reduccio:...) | In | 115.AMB.Nivell | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3484247 | P0 | Level: P0 | 125 mmø-100 mmø | 0.000498915 | Mechanical IC.AIRE.Extracció.Serveis 3
3484396 | P0 | Level: P0 | 125 mmø-100 mmø | 0.000498915 | Mechanical IC.AIRE.Extracció.Serveis 2
3484513 | P0 | Level: P0 | 160 mmø-125 mmø | 0.00112171 | Mechanical IC.AIRE.Extracció.Serveis 1
3484669 | P0 | Level: P0 | 125 mmø-100 mmø | 0.000498836 | Mechanical IC.AIRE.Extracció.Serveis 3
3484712 | P0 | Level: P0 | 125 mmø-100 mmø | 0.000498836 | Mechanical IC.AIRE.Extracció.Serveis 2
3484762 | P0 | Level: P0 | 125 mmø-100 mmø | 0.000498836 | Mechanical IC.AIRE.Extracció.Serveis 4
3658414 | P1 | Level: P1 | 125 mmø-100 mmø | 0.000498915 | Mechanical IC.AIRE.Extracció.Serveis 6
3658468 | P1 | Level: P1 | 125 mmø-100 mmø | 0.000498836 | Mechanical IC.AIRE.Extracció.Serveis 6
3695560 | P1 | Level: P1 | 150 mmø-125 mmø | 0.000744273 | Mechanical IC.AIRE.Extracció.Serveis 9
3695709 | P1 | Level: P1 | 150 mmø-125 mmø | 0.000744273 | Mechanical IC.AIRE.Extracció.Serveis 9
3696649 | P1 | Level: P1 | 150 mmø-125 mmø | 0.000744304 | Mechanical IC.AIRE.Extracció.Serveis 9
3696669 | P1 | Level: P1 | 125 mmø-100 mmø | 0.000498836 | Mechanical IC.AIRE.Extracció.Serveis 9
3696906 | P0 | Level: P0 | 150 mmø-125 mmø | 0.000744273 | Mechanical IC.AIRE.Extracció.Serveis 11
3696910 | P0 | Level: P0 | 150 mmø-125 mmø | 0.000744273 | Mechanical IC.AIRE.Extracció.Serveis 11
3696914 | P0 | Level: P0 | 150 mmø-125 mmø | 0.000744304 | Mechanical IC.AIRE.Extracció.Serveis 11
3696918 | P0 | Level: P0 | 125 mmø-100 mmø | 0.000498836 | Mechanical IC.AIRE.Extracció.Serveis 11

# IfcFlowFitting: AMB_Reducció_Xapa_Rectangular:AMB.CLI.ConducteRectangular.Reducció.Retorn (46)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Duct Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.40; 105.AMB.ClassificacioDescripcio: Retorn de aire tractat; 109.AMB.CodiTipus: CLI34; 111.AMB.DescripcioTipus: Conducte rectangular. Reducció. Retorn
Classification: 50.30.40.40 Retorn de aire tractat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB_Reducció_Xapa_Rectangular:AMB.CLI.ConducteRectangular.Reducció.Retorn; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Reducció_Xapa_Rectangular: AMB.CLI.ConducteRectangular.Reducció.Retorn; 119.AMB.FaseCreacio: Obra
Name (AMB_Reducció_Xapa_Rectangular:AMB.CLI.ConducteRectangular.Reducció.Retorn:...) | In | 112.AMB.Servei | 115.AMB.Nivell | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3447156 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 650 mmx250 mm-500 mmx250 mm | 0.043125 | Mechanical IC.AIRE.Aportació 5
3447157 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 500 mmx250 mm-450 mmx250 mm | 0.011875 | Mechanical IC.AIRE.Aportació 5
3447260 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 250 mmx250 mm-250 mmx150 mm | 0.01 | Mechanical IC.AIRE.Aportació 5
3447370 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 450 mmx250 mm-350 mmx300 mm | 0.0438333 | Mechanical IC.AIRE.Aportació 5
3447884 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 400 mmx250 mm-250 mmx250 mm | 0.040625 | Mechanical IC.AIRE.Aportació 5
3447886 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 350 mmx300 mm-400 mmx250 mm | 0.0102917 | Mechanical IC.AIRE.Aportació 5
3448390 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 250 mmx250 mm-250 mmx150 mm | 0.01 | Mechanical IC.AIRE.Aportació 5
3448492 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 250 mmx250 mm-400 mmx150 mm | 0.019125 | Mechanical IC.AIRE.Aportació 5
3462722 | P0 | Duct System: IC.AIRE.ExtraccióPrimari | Level: P0 | 900 mmx250 mm-315 mmx315 mm | 0.084225 | Mechanical IC.AIRE.ExtraccióPrimari 3
3462930 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 900 mmx250 mm-315 mmx315 mm | 0.0421125 | Mechanical IC.AIRE.Aportació 4
3463018 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 1000 mmx150 mm-315 mmx315 mm | 0.071725 | Mechanical IC.AIRE.Aportació 5
3463074 | P0 | Duct System: IC.AIRE.ExtraccióPrimari | Level: P0 | 900 mmx250 mm-315 mmx315 mm | 0.084225 | Mechanical IC.AIRE.ExtraccióPrimari 2
3464117 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 650 mmx250 mm-1000 mmx150 mm | 0.0810417 | Mechanical IC.AIRE.Aportació 5
3464204 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 250 mmx250 mm-250 mmx250 mm | 0.015625 | Mechanical IC.AIRE.Aportació 5
3471479 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 250 mmx150 mm-250 mmx100 mm | 0.003125 | Mechanical IC.AIRE.Aportació 5
3471490 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 250 mmx150 mm-250 mmx100 mm | 0.003125 | Mechanical IC.AIRE.Aportació 5
3471531 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 250 mmx250 mm-250 mmx150 mm | 0.01 | Mechanical IC.AIRE.Aportació 5
3471565 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 250 mmx150 mm-250 mmx100 mm | 0.003125 | Mechanical IC.AIRE.Aportació 5
3479310 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 1000 mmx150 mm-400 mmx150 mm | 0.0525 | Mechanical IC.AIRE.Aportació 5
3479311 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 1000 mmx150 mm-400 mmx150 mm | 0.021 | Mechanical IC.AIRE.Aportació 5
3697069 | P1 | Duct System: IC.AIRE.ExtraccióPrimari | Level: P1 | 900 mmx250 mm-315 mmx315 mm | 0.084225 | Mechanical IC.AIRE.ExtraccióPrimari 4
3697071 | P1 | Duct System: IC.AIRE.Aportació | Level: P1 | 900 mmx250 mm-315 mmx315 mm | 0.084225 | Mechanical IC.AIRE.Aportació 2
3697072 | P1 | Duct System: IC.AIRE.Aportació | Level: P1 | 1000 mmx150 mm-315 mmx315 mm | 0.071725 | Mechanical IC.AIRE.Aportació 3
3697100 | P1 | Duct System: IC.AIRE.Aportació | Level: P1 | 1000 mmx150 mm-400 mmx150 mm | 0.021 | Mechanical IC.AIRE.Aportació 3
3699052 | P1 | Duct System: IC.AIRE.Aportació | Level: P1 | 400 mmx250 mm-200 mmx200 mm | 0.0273333 | Mechanical IC.AIRE.Aportació 3
3699076 | P1 | Duct System: IC.AIRE.Aportació | Level: P1 | 275 mmx150 mm-200 mmx200 mm | 0.0061875 | Mechanical IC.AIRE.Aportació 3
3699077 | P1 | Duct System: IC.AIRE.Aportació | Level: P1 | 1000 mmx150 mm-275 mmx150 mm | 0.0478125 | Mechanical IC.AIRE.Aportació 3
3699162 | P1 | Duct System: IC.AIRE.Aportació | Level: P1 | 250 mmx250 mm-250 mmx100 mm | 0.013125 | Mechanical IC.AIRE.Aportació 3
3773589 | P1 | Duct System: IC.AIRE.ExtraccióPrimari | Level: P1 | 900 mmx250 mm-315 mmx315 mm | 0.084225 | Mechanical IC.AIRE.ExtraccióPrimari 1
3777715 | P1 | Duct System: IC.AIRE.Aportació | Level: P1 | 1000 mmx150 mm-400 mmx150 mm | 0.0525 | Mechanical IC.AIRE.Aportació 3
3777716 | P1 | Duct System: IC.AIRE.Aportació | Level: P1 | 400 mmx250 mm-400 mmx150 mm | 0.016 | Mechanical IC.AIRE.Aportació 3
3778194 | P1 | Duct System: IC.AIRE.Aportació | Level: P1 | 500 mmx250 mm-400 mmx250 mm | 0.0225 | Mechanical IC.AIRE.Aportació 3
3778734 | P1 | Duct System: IC.AIRE.Aportació | Level: P1 | 400 mmx250 mm-400 mmx150 mm | 0.016 | Mechanical IC.AIRE.Aportació 3
3778773 | P1 | Duct System: IC.AIRE.Aportació | Level: P1 | 1000 mmx150 mm-400 mmx150 mm | 0.0525 | Mechanical IC.AIRE.Aportació 3
3779152 | P1 | Duct System: IC.AIRE.Aportació | Level: P1 | 550 mmx300 mm-1000 mmx150 mm | 0.084375 | Mechanical IC.AIRE.Aportació 3
3779153 | P1 | Duct System: IC.AIRE.Aportació | Level: P1 | 550 mmx300 mm-500 mmx250 mm | 0.0144583 | Mechanical IC.AIRE.Aportació 3
3781794 | S1 | Duct System: IC.AIRE.ExtraccióPrimari | Level: S1 | 900 mmx500 mm-900 mmx250 mm | 0.016875 | Mechanical IC.AIRE.ExtraccióPrimari 2
3782072 | P1 | Duct System: IC.AIRE.ExtraccióPrimari | Level: P1 | 900 mmx500 mm-900 mmx250 mm | 0.016875 | Mechanical IC.AIRE.ExtraccióPrimari 1
3782821 | P1 | Duct System: IC.AIRE.Aportació | Level: P1 | 400 mmx400 mm-400 mmx250 mm | 0.0065 | Mechanical IC.AIRE.Aportació 3
3782823 | P1 | Duct System: IC.AIRE.Aportació | Level: P1 | 600 mmx200 mm-400 mmx250 mm | 0.00558333 | Mechanical IC.AIRE.Aportació 3
3782990 | S1 | Duct System: IC.AIRE.Aportació | Level: S1 | 400 mmx350 mm-400 mmx250 mm | 0.006 | Mechanical IC.AIRE.Aportació 5
3782992 | S1 | Duct System: IC.AIRE.Aportació | Level: S1 | 600 mmx200 mm-400 mmx250 mm | 0.00558333 | Mechanical IC.AIRE.Aportació 5
3783159 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 400 mmx650 mm-400 mmx250 mm | 0.009 | Mechanical IC.AIRE.Aportació 5
3783161 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 600 mmx200 mm-400 mmx250 mm | 0.00558333 | Mechanical IC.AIRE.Aportació 5
3783176 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 400 mmx500 mm-400 mmx250 mm | 0.0075 | Mechanical IC.AIRE.Aportació 5
3783178 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 600 mmx200 mm-400 mmx250 mm | 0.00558333 | Mechanical IC.AIRE.Aportació 5

# IfcFlowFitting: AMB_Reducción_PVC_L2:AMB.SAN.PVC.UNE-EN 1329-1_Serie B (4)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals; 109.AMB.CodiTipus: SAN12; 111.AMB.DescripcioTipus: Reducció PVC
Classification: 50.20.20.20 Canalitzacions d'aigües residuals (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB_Reducción_PVC_L2:AMB.SAN.PVC.UNE-EN 1329-1_Serie B; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Reducción_PVC_L2: AMB.SAN.PVC.UNE-EN 1329-1_Serie B; 119.AMB.FaseCreacio: Obra
Name (AMB_Reducción_PVC_L2:AMB.SAN.PVC.UNE-EN 1329-1_Serie B:...) | In | 112.AMB.Servei | 115.AMB.Nivell | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3532660 | P1 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø-50 mmø | 0.0000980352 | IF.SANE.Fecal 7
3532667 | P1 | Piping System: IF.SANE.Fecal | Level: P1 | 50 mmø-50 mmø | 0.0000980352 | IF.SANE.Fecal 7
3539793 | P2 | Piping System: IF.SANE.Pluvial | Level: P2 | 125 mmø-90 mmø | 0.000823691 | IF.SANE.Pluvial 11
3543267 | P0 | Piping System: IF.SANE.Fecal | Level: P0 | 125 mmø-110 mmø | 0.00135672 | IF.SANE.Fecal 7

# IfcFlowFitting: AMB_Reducción_PVC_L2:UNE-EN 1329-1_Serie B, AMB_Reducción_PVC_L2:UNE-EN 1329-1_Serie B:3770923
In: P0
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals
Classification: 50.20.20.20 Canalitzacions d'aigües residuals (Uniformat); Group: IF.SANE.Fecal 4
Pset_DistributionFlowElementCommon - Reference: AMB_Reducción_PVC_L2:UNE-EN 1329-1_Serie B; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Reducción_PVC_L2: UNE-EN 1329-1_Serie B; 112.AMB.Servei: Piping System: IF.SANE.Fecal; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 90 mmø-50 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.000197519 m3

# IfcFlowFitting: AMB_Te-reducida_PVC_L2:AMB.SAN.PVC.UNE-EN 1329-1_Serie B (14)
Type - Classification: 50.20.20.20 Canalitzacions d'aigües residuals (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals; 109.AMB.CodiTipus: SAN18; 111.AMB.DescripcioTipus: Te reduida
Pset_DistributionFlowElementCommon - Reference: AMB_Te-reducida_PVC_L2:AMB.SAN.PVC.UNE-EN 1329-1_Serie B; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Te-reducida_PVC_L2: AMB.SAN.PVC.UNE-EN 1329-1_Serie B; 112.AMB.Servei: Piping System: IF.SANE.Fecal; 119.AMB.FaseCreacio: Obra
Name (AMB_Te-reducida_PVC_L2:AMB.SAN.PVC.UNE-EN 1329-1_Serie B:...) | In | 115.AMB.Nivell | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3532655 | P1 | Level: P1 | 50 mmø-50 mmø-50 mmø | 0.000165496 | IF.SANE.Fecal 7
3532663 | P1 | Level: P1 | 50 mmø-50 mmø-50 mmø | 0.000165496 | IF.SANE.Fecal 7
3532949 | P1 | Level: P1 | 110 mmø-110 mmø-50 mmø | 0.00091685 | IF.SANE.Fecal 7
3533239 | P0 | Level: P0 | 110 mmø-110 mmø-110 mmø | 0.00175681 | IF.SANE.Fecal 7
3533250 | P0 | Level: P0 | 110 mmø-110 mmø-110 mmø | 0.00220854 | IF.SANE.Fecal 7
3533297 | P0 | Level: P0 | 50 mmø-50 mmø-50 mmø | 0.000165496 | IF.SANE.Fecal 3
3533332 | P0 | Level: P0 | 50 mmø-50 mmø-50 mmø | 0.000165496 | IF.SANE.Fecal 3
3533359 | P0 | Level: P0 | 110 mmø-110 mmø-110 mmø | 0.00175684 | IF.SANE.Fecal 7
3533826 | P0 | Level: P0 | 110 mmø-110 mmø-110 mmø | 0.00175681 | IF.SANE.Fecal 7
3543318 | P0 | Level: P0 | 125 mmø-125 mmø-110 mmø | 0.00298881 | IF.SANE.Fecal 7
3637534 | P0 | Level: P0 | 20 mmø-20 mmø-20 mmø | 0.0000306611 | IF.SANE.Fecal 2
3776201 | P0 | Level: P0 | 20 mmø-20 mmø-20 mmø | 0.0000306611 | IF.SANE.Fecal 2
3776275 | P0 | Level: P0 | 20 mmø-20 mmø-20 mmø | 0.0000306611 | IF.SANE.Fecal 2
3776318 | P0 | Level: P0 | 20 mmø-20 mmø-20 mmø | 0.0000306611 | IF.SANE.Fecal 2

# IfcFlowFitting: AMB_Te_Acer-carboni_Soldar:AMB.PCI.Acer.EN 10253-1_Series 2 (3)
In: P0
Type - Material: Metal.Steel.Carbon1
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.50.10.70; 105.AMB.ClassificacioDescripcio: BIES; 109.AMB.CodiTipus: PCI13; 111.AMB.DescripcioTipus: Element de muntatge de Tub en acer segons EN10253-1 - T
Classification: 50.50.10.70 BIES (Uniformat); Group: IF.EXTI.BIEs 5
Pset_DistributionFlowElementCommon - Reference: AMB_Te_Acer-carboni_Soldar:AMB.PCI.Acer.EN 10253-1_Series 2; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Te_Acer-carboni_Soldar: AMB.PCI.Acer.EN 10253-1_Series 2; 112.AMB.Servei: Piping System: IF.EXTI.BIEs; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
Name (AMB_Te_Acer-carboni_Soldar:AMB.PCI.Acer.EN 10253-1_Series 2:...) | 242.AMB.Mida | 509.AMB.Volum (m3)
3402727 | 40 mmø-40 mmø-40 mmø | 0.000275743
3403581 | 50 mmø-50 mmø-50 mmø | 0.000475203
3783785 | 40 mmø-40 mmø-40 mmø | 0.000275743

# IfcFlowFitting: AMB_Te_Acer-inoxidable_Soldar:AMB.CLI.Tuberia.AcerGalvanitzat.Tee (6)
Type - Material: Metal.Steel.Stainless1
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.30.20; 105.AMB.ClassificacioDescripcio: Línies hidràuliques; 109.AMB.CodiTipus: CLI24; 111.AMB.DescripcioTipus: Te acer inoxidable
Classification: 50.30.30.20 Línies hidràuliques (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB_Te_Acer-inoxidable_Soldar:AMB.CLI.Tuberia.AcerGalvanitzat.Tee; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Te_Acer-inoxidable_Soldar: AMB.CLI.Tuberia.AcerGalvanitzat.Tee; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 20 mmø-20 mmø-20 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.0000429536 m3
Name (AMB_Te_Acer-inoxidable_Soldar:AMB.CLI.Tuberia.AcerGalvanitzat.Tee:...) | In | 112.AMB.Servei | 115.AMB.Nivell | Group
3672911 | P1 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P1 | IC.AIGUA.Calenta.Retorn 3
3672937 | P1 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | IC.AIGUA.Calenta.Impulsió 3
3673241 | P1 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | IC.AIGUA.Calenta.Impulsió 3
3673247 | P1 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P1 | IC.AIGUA.Calenta.Retorn 3
3682873 | P0 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | IC.AIGUA.Calenta.Retorn 3
3682881 | P0 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | IC.AIGUA.Calenta.Impulsió 3

# IfcFlowFitting: AMB_Te_Canal:AMB.ELE.TeCanal, AMB_Te_Canal:AMB.ELE.TeCanal:3746497
In: P0
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Cable Tray Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.30.10; 105.AMB.ClassificacioDescripcio: Safates de distribució elèctrica; 109.AMB.CodiTipus: ELE29; 111.AMB.DescripcioTipus: Safata metàl·lica reixa amb separadors d'acer per cable electrics - T
Type - 2 AMB.Caracteristiques - 224.AMB.IP: IP44; 225.AMB.IK: IK04
Classification: 50.60.30.10 Safates de distribució elèctrica (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB_Te_Canal:AMB.ELE.TeCanal; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Te_Canal: AMB.ELE.TeCanal; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 503.AMB.Altura: 3 cm; 504.AMB.Gruix: 0.254 cm; 509.AMB.Volum: 0.00137574 m3

# IfcFlowFitting: AMB_Te_Socket:AMB.SAN.PVC.Te.UNE EN 1329-1_HH (15)
In: P0
Type - Classification: 50.20.20.20 Canalitzacions d'aigües residuals (Uniformat); Material: Plastic.PVC·U
Type - Pset_ProductRequirements - Category: Pipe Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals; 109.AMB.CodiTipus: SAN15; 111.AMB.DescripcioTipus: Accesori tuberies segons UNE EN 1329-1 - Te
Pset_DistributionFlowElementCommon - Reference: AMB_Te_Socket:AMB.SAN.PVC.Te.UNE EN 1329-1_HH; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Te_Socket: AMB.SAN.PVC.Te.UNE EN 1329-1_HH; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
Name (AMB_Te_Socket:AMB.SAN.PVC.Te.UNE EN 1329-1_HH:...) | 112.AMB.Servei | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3535785 | Piping System: IF.SANE.Pluvial | 160 mmø-160 mmø-160 mmø | 0.00865562 | IF.SANE.Pluvial 6
3537042 | Piping System: IF.SANE.Pluvial | 160 mmø-160 mmø-160 mmø | 0.00971769 | IF.SANE.Pluvial 11
3537360 | Piping System: IF.SANE.Pluvial | 160 mmø-160 mmø-160 mmø | 0.0148985 | IF.SANE.Pluvial 6
3538128 | Piping System: IF.SANE.Pluvial | 160 mmø-160 mmø-160 mmø | 0.00971761 | IF.SANE.Pluvial 11
3539395 | Piping System: IF.SANE.Pluvial | 160 mmø-160 mmø-160 mmø | 0.0208556 | IF.SANE.Pluvial 5
3540270 | Piping System: IF.SANE.Pluvial | 160 mmø-160 mmø-160 mmø | 0.00567977 | IF.SANE.Pluvial 5
3543582 | Piping System: IF.SANE.Pluvial | 160 mmø-160 mmø-160 mmø | 0.0053282 | IF.SANE.Pluvial 3
3543980 | Piping System: IF.SANE.Pluvial | 125 mmø-125 mmø-125 mmø | 0.00412732 | IF.SANE.Pluvial 3
3544167 | Piping System: IF.SANE.Pluvial | 125 mmø-125 mmø-125 mmø | 0.00336419 | IF.SANE.Pluvial 5
3770877 | Piping System: IF.SANE.Fecal | 125 mmø-125 mmø-125 mmø | 0.00294175 | IF.SANE.Fecal 4
3770885 | Piping System: IF.SANE.Fecal | 125 mmø-125 mmø-125 mmø | 0.00278145 | IF.SANE.Fecal 4
3770891 | Piping System: IF.SANE.Fecal | 125 mmø-125 mmø-125 mmø | 0.00514332 | IF.SANE.Fecal 4
3770913 | Piping System: IF.SANE.Fecal | 125 mmø-125 mmø-125 mmø | 0.00345654 | IF.SANE.Fecal 4
3770945 | Piping System: IF.SANE.Fecal | 110 mmø-110 mmø-110 mmø | 0.00287529 | IF.SANE.Fecal 4
3770957 | Piping System: IF.SANE.Fecal | 125 mmø-125 mmø-125 mmø | 0.00267455 | IF.SANE.Fecal 4

# IfcFlowFitting: AMB_Te_Xapa_Rectangular:AMB.CLI.ConducteXapa.Rectangular.Te.Retorn (13)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Duct Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.40; 105.AMB.ClassificacioDescripcio: Retorn de aire tractat; 109.AMB.CodiTipus: CLI31; 111.AMB.DescripcioTipus: Conducte xapa. Rectangular. Te. Retorn
Classification: 50.30.40.40 Retorn de aire tractat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB_Te_Xapa_Rectangular:AMB.CLI.ConducteXapa.Rectangular.Te.Retorn; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Te_Xapa_Rectangular: AMB.CLI.ConducteXapa.Rectangular.Te.Retorn; 112.AMB.Servei: Duct System: IC.AIRE.Aportació; 119.AMB.FaseCreacio: Obra
Name (AMB_Te_Xapa_Rectangular:AMB.CLI.ConducteXapa.Rectangular.Te.Retorn:...) | In | 115.AMB.Nivell | 242.AMB.Mida | 503.AMB.Altura (cm) | 509.AMB.Volum (m3) | Group
3447256 | P0 | Level: P0 | 500 mmx250 mm-500 mmx250 mm-250 mmx250 mm | 25 | 0.046875 | Mechanical IC.AIRE.Aportació 5
3448386 | P0 | Level: P0 | 250 mmx250 mm-250 mmx250 mm-250 mmx250 mm | 25 | 0.025 | Mechanical IC.AIRE.Aportació 5
3464095 | P0 | Level: P0 | 1000 mmx150 mm-1000 mmx150 mm-400 mmx150 mm | 15 | 0.078 | Mechanical IC.AIRE.Aportació 5
3464200 | P0 | Level: P0 | 650 mmx250 mm-650 mmx250 mm-250 mmx250 mm | 25 | 0.06 | Mechanical IC.AIRE.Aportació 5
3471527 | P0 | Level: P0 | 400 mmx250 mm-400 mmx250 mm-250 mmx250 mm | 25 | 0.038125 | Mechanical IC.AIRE.Aportació 5
3697077 | P1 | Level: P1 | 1000 mmx150 mm-1000 mmx150 mm-400 mmx150 mm | 15 | 0.078 | Mechanical IC.AIRE.Aportació 3
3699014 | P1 | Level: P1 | 400 mmx250 mm-400 mmx250 mm-250 mmx250 mm | 25 | 0.038125 | Mechanical IC.AIRE.Aportació 3
3777705 | P1 | Level: P1 | 400 mmx250 mm-400 mmx250 mm-400 mmx250 mm | 25 | 0.055 | Mechanical IC.AIRE.Aportació 3
3778719 | P1 | Level: P1 | 500 mmx250 mm-500 mmx250 mm-400 mmx250 mm | 25 | 0.0675 | Mechanical IC.AIRE.Aportació 3
3782817 | P1 | Level: P1 | 400 mmx400 mm-250 mmx400 mm-250 mmx400 mm | 40 | 0.058 | Mechanical IC.AIRE.Aportació 3
3782986 | S1 | Level: S1 | 400 mmx350 mm-300 mmx350 mm-300 mmx350 mm | 35 | 0.0595 | Mechanical IC.AIRE.Aportació 5
3783155 | P0 | Level: P0 | 400 mmx650 mm-250 mmx650 mm-250 mmx650 mm | 65 | 0.09425 | Mechanical IC.AIRE.Aportació 5
3783172 | P0 | Level: P0 | 400 mmx500 mm-250 mmx500 mm-250 mmx500 mm | 50 | 0.0725 | Mechanical IC.AIRE.Aportació 5

# IfcFlowFitting: AMB_Tremuja:AMB.CLI.Conducte.Conversió.Retorn (11)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Duct Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.40; 105.AMB.ClassificacioDescripcio: Retorn de aire tractat; 109.AMB.CodiTipus: CLI25; 111.AMB.DescripcioTipus: Tremuja
Classification: 50.30.40.40 Retorn de aire tractat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMB_Tremuja:AMB.CLI.Conducte.Conversió.Retorn; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Tremuja: AMB.CLI.Conducte.Conversió.Retorn; 119.AMB.FaseCreacio: Obra
Name (AMB_Tremuja:AMB.CLI.Conducte.Conversió.Retorn:...) | In | 112.AMB.Servei | 115.AMB.Nivell | 242.AMB.Mida | 503.AMB.Altura (cm) | 509.AMB.Volum (m3) | Group
3456065 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 315 mmx315 mm-315 mmø | 31.5 | 0.00430588 | Mechanical IC.AIRE.Aportació 4
3456118 | P0 | Duct System: IC.AIRE.Aportació | Level: P0 | 315 mmx315 mm-315 mmø | 31.5 | 0.00430588 | Mechanical IC.AIRE.Aportació 5
3456151 | P0 | Duct System: IC.AIRE.ExtraccióPrimari | Level: P0 | 315 mmx315 mm-315 mmø | 31.5 | 0.00430588 | Mechanical IC.AIRE.ExtraccióPrimari 2
3456189 | P0 | Duct System: IC.AIRE.ExtraccióPrimari | Level: P0 | 315 mmx315 mm-315 mmø | 31.5 | 0.00430588 | Mechanical IC.AIRE.ExtraccióPrimari 3
3697062 | P1 | Duct System: IC.AIRE.Aportació | Level: P1 | 315 mmx315 mm-315 mmø | 31.5 | 0.00430588 | Mechanical IC.AIRE.Aportació 2
3697064 | P1 | Duct System: IC.AIRE.Aportació | Level: P1 | 315 mmx315 mm-315 mmø | 31.5 | 0.00430588 | Mechanical IC.AIRE.Aportació 3
3697066 | P1 | Duct System: IC.AIRE.ExtraccióPrimari | Level: P1 | 315 mmx315 mm-315 mmø | 31.5 | 0.00430588 | Mechanical IC.AIRE.ExtraccióPrimari 1
3697068 | P1 | Duct System: IC.AIRE.ExtraccióPrimari | Level: P1 | 315 mmx315 mm-315 mmø | 31.5 | 0.00430588 | Mechanical IC.AIRE.ExtraccióPrimari 4
3780282 | S1 | Duct System: IC.AIRE.Extracció | Level: S1 | 200 mmx50 mm-90 mmø | 5 | 0.000446569 | Mechanical IC.AIRE.Extracció 1
3780641 | S1 | Duct System: IC.AIRE.Extracció | Level: S1 | 200 mmx50 mm-90 mmø | 5 | 0.000446569 | Mechanical IC.AIRE.Extracció 2
3780898 | P0 | Duct System: IC.AIRE.Extracció.Serveis | Level: P0 | 50 mmx200 mm-90 mmø | 20 | 0.000405688 | Mechanical IC.AIRE.Extracció.Serveis 1

# IfcFlowFitting: AMD_Passatubs_Colze:AMB.COM.Passatubs.Colze (33)
In: P2
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Conduit Fittings
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.70.10.20; 105.AMB.ClassificacioDescripcio: Escomeses de telecomunicacions; 109.AMB.CodiTipus: COM04; 111.AMB.DescripcioTipus: Colze passatubs
Classification: 50.70.10.20 Escomeses de telecomunicacions (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AMD_Passatubs_Colze:AMB.COM.Passatubs.Colze; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMD_Passatubs_Colze: AMB.COM.Passatubs.Colze; 115.AMB.Nivell: Level: P2; 119.AMB.FaseCreacio: Obra
Name (AMD_Passatubs_Colze:AMB.COM.Passatubs.Colze:...) | 509.AMB.Volum (m3)
3755845 | 0.00118272
3755847 | 0.00118272
3756200 | 0.00118272
3756202 | 0.00118272
3756217 | 0.00118272
3756219 | 0.00118272
3756232 | 0.00118272
3756234 | 0.00118272
3756249 | 0.00118272
3756251 | 0.00118272
3756264 | 0.00118272
3756266 | 0.00118272
3756279 | 0.00118272
3756281 | 0.00118272
3756296 | 0.00118272
3756298 | 0.00118272
3756323 | 0.00118272
3756325 | 0.00118272
3756338 | 0.00118272
3756340 | 0.00118272
3756353 | 0.00118272
3756355 | 0.00118272
3756366 | 0.00118272
3756368 | 0.00118272
3756379 | 0.00118272
3756381 | 0.00118272
3756392 | 0.00118272
3756394 | 0.00118272
3756544 | 0.00144457
3756561 | 0.000671515
3756573 | 0.00105804
3780365 | 0.00118272
3780367 | 0.00118272

# IfcFlowSegment: Cable Tray with Fittings:AMB.COM.Safata.Pemsa (12)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Pemsa
Type - Pset_ProductRequirements - Category: Cable Trays
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.70.30.10; 105.AMB.ClassificacioDescripcio: Safates de distribució per a senyals dèbils; 109.AMB.CodiTipus: COM10; 111.AMB.DescripcioTipus: Safata metàl·lica reixa amb separadors d'acer per cable electrics
Type - 3 AMB.Fabricant - 301.AMB.Fabricant: Pemsa
Classification: 50.70.30.10 Safates de distribució per a senyals dèbils (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Cable Tray with Fittings:AMB.COM.Safata.Pemsa; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: Cable Tray with Fittings: AMB.COM.Safata.Pemsa; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 502.AMB.Amplada: 15 cm; 503.AMB.Altura: 3 cm; sets with these values: 2
Name (Cable Tray with Fittings:AMB.COM.Safata.Pemsa:...) | In | Length (cm) = 501.AMB.Longitud (cm) | 115.AMB.Nivell
3531209 | P0 | 129.5 | Level: P0
3531412 | P0 | 1018.48 | Level: P0
3531439 | P0 | 726.943 | Level: P0
3531531 | P0 | 15.6326 | Level: P0
3531563 | P1 | 131 | Level: P1
3531564 | P1 | 2580.16 | Level: P1
3531566 | P1 | 725.607 | Level: P1
3531567 | P1 | 15.6326 | Level: P1
3746487 | P0 | 288.343 | Level: P0
3746498 | P0 | 1521.68 | Level: P0
3747027 | P0 | 10.3475 | Level: P0
3747108 | P0 | 133.5 | Level: P0

# IfcFlowSegment: Conduit with Fittings:AMB.ELE.Passatubs (18)
In: P2
Type - Pset_ProductRequirements - Category: Conduits
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.30.40; 105.AMB.ClassificacioDescripcio: Mànegues i tubs de distribució elèctrica; 109.AMB.CodiTipus: ELE07; 111.AMB.DescripcioTipus: Passatubs. Electricitat
Classification: 50.60.30.40 Mànegues i tubs de distribució elèctrica (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Conduit with Fittings:AMB.ELE.Passatubs; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: Conduit with Fittings: AMB.ELE.Passatubs; 115.AMB.Nivell: Level: P2; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - sets with these values: 2
Name (Conduit with Fittings:AMB.ELE.Passatubs:...) | Length (cm) = 501.AMB.Longitud (cm)
3755763 | 3.63424
3756199 | 3.63424
3756216 | 3.63424
3756231 | 3.63424
3756248 | 3.63424
3756263 | 3.63424
3756278 | 3.63424
3756295 | 3.63424
3756322 | 3.63424
3756337 | 3.63424
3756352 | 3.63424
3756365 | 3.63424
3756378 | 3.63424
3756391 | 3.63424
3756526 | 799.019
3756535 | 33.2721
3756547 | 3.99428
3780364 | 3.63424

# IfcFlowSegment: Flex Duct Round:Flex - Round (3)
Type - Pset_ElementShading - Roughness: 0.009144 cm
Type - Pset_ProductRequirements - Category: Flex Ducts
Pset_DistributionFlowElementCommon - Reference: Flex Duct Round:Flex - Round; sets with these values: 2
Pset_DuctSegmentTypeCommon - sets with these values: 3
1 AMB.Identificacio - 107.AMB.NomTipus: Flex Duct Round: Flex - Round; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 90 mmø
5 AMB.Geometria - 505.AMB.Diametre: 9 cm
Name (Flex Duct Round:Flex - Round:...) | In | Length (cm) = 501.AMB.Longitud (cm) | 112.AMB.Servei | 115.AMB.Nivell | Group
3780279 | S1 | 3.99767 | Duct System: IC.AIRE.Extracció | Level: S1 | Mechanical IC.AIRE.Extracció 1
3780638 | S1 | 3.99767 | Duct System: IC.AIRE.Extracció | Level: S1 | Mechanical IC.AIRE.Extracció 2; Mechanical IC.AIRE.Extracció.Serveis 4
3780895 | P0 | 8.04028 | Duct System: IC.AIRE.Extracció.Serveis | Level: P0 | Mechanical IC.AIRE.Extracció.Serveis 1

# IfcFlowSegment: Pipe Types:AMB.CLI.Tuberia.AcerGalvanitzat (58)
Type - Pset_ProductRequirements - Category: Pipes
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.30.20; 105.AMB.ClassificacioDescripcio: Línies hidràuliques; 109.AMB.CodiTipus: CLI27; 111.AMB.DescripcioTipus: Tuberia acer galvanitzat
Classification: 50.30.30.20 Línies hidràuliques (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:AMB.CLI.Tuberia.AcerGalvanitzat; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.000254 cm
1 AMB.Identificacio - 107.AMB.NomTipus: Pipe Types: AMB.CLI.Tuberia.AcerGalvanitzat; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 20 mmø
5 AMB.Geometria - 505.AMB.Diametre: 2 cm
Name (Pipe Types:AMB.CLI.Tuberia.AcerGalvanitzat:...) | In | Pset_FlowSegmentDuctSegment, Length (cm) = Pset_FlowSegmentPipeSegment, Length (cm) = 501.AMB.Longitud (cm) | InvertElevation (cm) | 112.AMB.Servei | 115.AMB.Nivell | 507.AMB.Area (m2) | Group
3671615 | P1 | 1002.12 | 650.755 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | 0.629653 | IC.AIGUA.Calenta.Impulsió 3
3671641 | P1 | 991.577 | 648.255 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P1 | 0.623026 | IC.AIGUA.Calenta.Retorn 3
3671955 | P1 | 341.7 | 307.4 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | 0.214696 | IC.AIGUA.Calenta.Impulsió 3
3671959 | P1 | 336.7 | 309.9 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P1 | 0.211555 | IC.AIGUA.Calenta.Retorn 3
3672431 | P1 | 266.7 | 379.9 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P1 | 0.167573 | IC.AIGUA.Calenta.Retorn 3
3672474 | P1 | 265.45 | 383.65 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | 0.166787 | IC.AIGUA.Calenta.Impulsió 3
3672608 | P1 | 92.7313 | 379.505 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | 0.0582648 | IC.AIGUA.Calenta.Impulsió 3
3672643 | P1 | 99.7313 | 375.755 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P1 | 0.062663 | IC.AIGUA.Calenta.Retorn 3
3672725 | P1 | 114.557 | 379.505 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | 0.071978 | IC.AIGUA.Calenta.Impulsió 3
3672753 | P1 | 120.057 | 375.755 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P1 | 0.0754337 | IC.AIGUA.Calenta.Retorn 3
3672799 | P1 | 329.383 | 648.255 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P1 | 0.206957 | IC.AIGUA.Calenta.Retorn 3
3672801 | P1 | 330.883 | 650.755 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | 0.2079 | IC.AIGUA.Calenta.Impulsió 3
3672903 | P1 | 309.348 | 648.255 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P1 | 0.194369 | IC.AIGUA.Calenta.Retorn 3
3672912 | P1 | 313.046 | 648.255 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P1 | 0.196692 | IC.AIGUA.Calenta.Retorn 3
3672931 | P1 | 321.596 | 650.755 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | 0.202065 | IC.AIGUA.Calenta.Impulsió 3
3672938 | P1 | 305.225 | 650.755 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | 0.191779 | IC.AIGUA.Calenta.Impulsió 3
3672992 | P1 | 266.7 | 379.9 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P1 | 0.167573 | IC.AIGUA.Calenta.Retorn 3
3672994 | P1 | 265.45 | 383.65 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | 0.166787 | IC.AIGUA.Calenta.Impulsió 3
3673175 | P1 | 3.7 | 379.505 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | 0.00232478 | IC.AIGUA.Calenta.Impulsió 3
3673214 | P1 | 3.7 | 379.505 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | 0.00232478 | IC.AIGUA.Calenta.Impulsió 3
3673242 | P1 | 149.6 | 650.755 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | 0.0939965 | IC.AIGUA.Calenta.Impulsió 3
3673248 | P1 | 131.13 | 648.255 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P1 | 0.0823913 | IC.AIGUA.Calenta.Retorn 3
3673619 | P1 | 19.793 | 442.207 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P1 | 0.0124363 | IC.AIGUA.Calenta.Retorn 3
3678098 | P0 | 7.21964 | 438.062 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | 0.00453623 | IC.AIGUA.Calenta.Retorn 3
3678144 | P1 | 204.393 | 442.207 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P1 | 0.128424 | IC.AIGUA.Calenta.Retorn 3
3678220 | P1 | 223.2 | 425.9 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | 0.140241 | IC.AIGUA.Calenta.Impulsió 3
3682240 | P1 | 36.1 | 425.9 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | 0.0226823 | IC.AIGUA.Calenta.Impulsió 3
3682254 | P1 | 33.1744 | 421.755 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P1 | 0.0208441 | IC.AIGUA.Calenta.Impulsió 3
3682310 | P0 | 308.357 | 303.255 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | 0.193746 | IC.AIGUA.Calenta.Impulsió 3
3682312 | P0 | 297.563 | 305.755 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | 0.186965 | IC.AIGUA.Calenta.Retorn 3
3682394 | P0 | 101.896 | 303.255 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | 0.0640229 | IC.AIGUA.Calenta.Impulsió 3
3682396 | P0 | 80.5977 | 305.755 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | 0.050641 | IC.AIGUA.Calenta.Retorn 3
3682413 | P0 | 54.8683 | 303.255 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | 0.0344748 | IC.AIGUA.Calenta.Impulsió 3
3682415 | P0 | 37.147 | 305.755 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | 0.0233401 | IC.AIGUA.Calenta.Retorn 3
3682491 | P0 | 274.2 | 29.9 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | 0.172285 | IC.AIGUA.Calenta.Retorn 3
3682501 | P0 | 32.011 | 25.755 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | 0.0201131 | IC.AIGUA.Calenta.Retorn 3
3682565 | P0 | 267.95 | 33.65 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | 0.168358 | IC.AIGUA.Calenta.Impulsió 3
3682639 | P0 | 2.52779 | 29.505 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | 0.00158826 | IC.AIGUA.Calenta.Impulsió 3
3682728 | P0 | 22.3356 | 29.505 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | 0.0140339 | IC.AIGUA.Calenta.Impulsió 3
3682892 | P0 | 8.39223 | 288.255 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | 0.005273 | IC.AIGUA.Calenta.Retorn 3
3682902 | P0 | 446.7 | 288.255 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | 0.28067 | IC.AIGUA.Calenta.Retorn 3
3682912 | P0 | 119.95 | 288.255 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | 0.0753668 | IC.AIGUA.Calenta.Retorn 3
3682922 | P0 | 219.756 | 288.255 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | 0.138077 | IC.AIGUA.Calenta.Retorn 3
3682960 | P0 | 12.1 | 285.755 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | 0.00760265 | IC.AIGUA.Calenta.Impulsió 3
3682970 | P0 | 451.248 | 285.755 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | 0.283527 | IC.AIGUA.Calenta.Impulsió 3
3682978 | P0 | 124.025 | 285.755 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | 0.0779274 | IC.AIGUA.Calenta.Impulsió 3
3682988 | P0 | 206.497 | 285.755 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | 0.129746 | IC.AIGUA.Calenta.Impulsió 3
3682996 | P0 | 52.2 | 285.755 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | 0.0327982 | IC.AIGUA.Calenta.Impulsió 3
3683031 | P0 | 34.2 | 288.255 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | 0.0214885 | IC.AIGUA.Calenta.Retorn 3
3683163 | P0 | 11.7628 | 29.505 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | 0.0073908 | IC.AIGUA.Calenta.Impulsió 3
3683196 | P0 | 22.2286 | 25.755 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | 0.0139666 | IC.AIGUA.Calenta.Retorn 3
3683221 | P0 | 256.7 | 29.9 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | 0.161289 | IC.AIGUA.Calenta.Retorn 3
3683244 | P0 | 250.45 | 33.65 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | 0.157362 | IC.AIGUA.Calenta.Impulsió 3
3683285 | S1 | 10.9567 | 29.505 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: S1 | 0.00688429 | IC.AIGUA.Calenta.Impulsió 3
3773055 | P0 | 156.169 | 305.755 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | 0.0981238 | IC.AIGUA.Calenta.Retorn 3
3773163 | P0 | 142.95 | 303.255 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | 0.0898181 | IC.AIGUA.Calenta.Impulsió 3
3773267 | P0 | 11.7 | 289.9 | Piping System: IC.AIGUA.Calenta.Impulsió | Level: P0 | 0.00735133 | IC.AIGUA.Calenta.Impulsió 3
3773301 | P0 | 11.7 | 292.4 | Piping System: IC.AIGUA.Calenta.Retorn | Level: P0 | 0.00735133 | IC.AIGUA.Calenta.Retorn 3

# IfcFlowSegment: Pipe Types:AMB.CLI.Tuberia.Coure (75)
Type - Pset_ProductRequirements - Category: Pipes
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.30.10; 105.AMB.ClassificacioDescripcio: Línies frigorífiques; 109.AMB.CodiTipus: CLI19; 111.AMB.DescripcioTipus: Canonade de Coure
Classification: 50.30.30.10 Línies frigorífiques (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:AMB.CLI.Tuberia.Coure; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: Pipe Types: AMB.CLI.Tuberia.Coure; 119.AMB.FaseCreacio: Obra
Name (Pipe Types:AMB.CLI.Tuberia.Coure:...) | In | Roughness (cm) | Pset_FlowSegmentDuctSegment, Length (cm) = Pset_FlowSegmentPipeSegment, Length (cm) = 501.AMB.Longitud (cm) | InvertElevation (cm) | 112.AMB.Servei | 115.AMB.Nivell | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (cm) | Group
3626672 | P2 | 0.000254 | 271.809 | 821.9 | Piping System: IC.REF.Gas | Level: P2 | 22 mmø | 0.187861 | 2.2 | IC.REF.Gas 2
3626685 | P2 | 0.000254 | 246.136 | 822.467 | Piping System: IC.REF.Liq | Level: P2 | 15 mmø | 0.115989 | 1.5 | IC.REF.Liq 1
3626862 | P2 | 0.000254 | 48.0081 | 822.467 | Piping System: IC.REF.Liq | Level: P2 | 15 mmø | 0.0226233 | 1.5 | IC.REF.Liq 1
3626878 | P2 | 0.000254 | 31.2138 | 822.467 | Piping System: IC.REF.Liq | Level: P2 | 15 mmø | 0.0147091 | 1.5 | IC.REF.Liq 1
3626904 | P2 | 0.000254 | 70.7088 | 821.9 | Piping System: IC.REF.Gas | Level: P2 | 22 mmø | 0.0488704 | 2.2 | IC.REF.Gas 2
3626913 | P2 | 0.000254 | 42.16 | 821.9 | Piping System: IC.REF.Gas | Level: P2 | 22 mmø | 0.0291389 | 2.2 | IC.REF.Gas 2
3635828 | P2 | 0.000254 | 1.62416 | 781.075 | Piping System: IC.REF.Gas | Level: P2 | 32 mmø | 0.00163278 | 3.2 | IC.REF.Gas 2
3635843 | P2 | 0.000254 | 6.78 | 781.075 | Piping System: IC.REF.Gas | Level: P2 | 32 mmø | 0.006816 | 3.2 | IC.REF.Gas 2
3635962 | P2 | 0.000254 | 135.991 | 821.9 | Piping System: IC.REF.Gas | Level: P2 | 22 mmø | 0.0939901 | 2.2 | IC.REF.Gas 2
3635970 | P2 | 0.000254 | 30.8079 | 821.9 | Piping System: IC.REF.Gas | Level: P2 | 22 mmø | 0.0212929 | 2.2 | IC.REF.Gas 2
3635979 | P2 | 0.000254 | 35.66 | 784.92 | Piping System: IC.REF.Gas | Level: P2 | 22 mmø | 0.0246464 | 2.2 | IC.REF.Gas 2
3636000 | P2 | 0.000254 | 129.952 | 822.467 | Piping System: IC.REF.Liq | Level: P2 | 15 mmø | 0.0612386 | 1.5 | IC.REF.Liq 1
3636008 | P2 | 0.000254 | 71.261 | 822.467 | Piping System: IC.REF.Liq | Level: P2 | 15 mmø | 0.033581 | 1.5 | IC.REF.Liq 1
3636016 | P2 | 0.000254 | 2.70564 | 822.467 | Piping System: IC.REF.Liq | Level: P2 | 15 mmø | 0.001275 | 1.5 | IC.REF.Liq 1
3636033 | P2 |  | 2.54 | 782.845 | Piping System: IC.REF.Liq | Level: P2 | 19 mmø | 0.00152411 | 1.91 | IC.REF.Liq 1
3636034 | P2 | 0.000254 | 35.9 | 785.45 | Piping System: IC.REF.Liq | Level: P2 | 15 mmø | 0.0169175 | 1.5 | IC.REF.Liq 1
3636510 | P2 | 0.000254 | 520.2 | 301.15 | Piping System: IC.REF.Liq | Level: P2 | 15 mmø | 0.245138 | 1.5 | IC.REF.Liq 1
3636535 | P2 | 0.000254 | 522.66 | 297.92 | Piping System: IC.REF.Gas | Level: P2 | 22 mmø | 0.361237 | 2.2 | IC.REF.Gas 2
3637771 | P0 | 0.000254 | 344.391 | 299.126 | Piping System: IC.REF.Liq | Level: P0 | 10 mmø | 0.108194 | 1 | IC.REF.Liq 1
3637780 | P0 | 0.000254 | 540.821 | 299.126 | Piping System: IC.REF.Liq | Level: P0 | 10 mmø | 0.169904 | 1 | IC.REF.Liq 1
3637794 | P0 | 0.000254 | 346.826 | 298.967 | Piping System: IC.REF.Liq | Level: P0 | 15 mmø | 0.163438 | 1.5 | IC.REF.Liq 1
3637807 | P0 | 0.000254 | 45.4466 | 298.967 | Piping System: IC.REF.Liq | Level: P0 | 15 mmø | 0.0214162 | 1.5 | IC.REF.Liq 1
3637829 | P0 | 0.000254 | 289.036 | 299.126 | Piping System: IC.REF.Liq | Level: P0 | 10 mmø | 0.0908033 | 1 | IC.REF.Liq 1
3637849 | P0 | 0.000254 | 149.44 | 299.126 | Piping System: IC.REF.Liq | Level: P0 | 10 mmø | 0.0469481 | 1 | IC.REF.Liq 1
3637908 | P0 | 0.000254 | 495.452 | 299.194 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø | 0.124521 | 0.8 | IC.REF.Liq 1
3637921 | P0 | 0.000254 | 495.452 | 299.194 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø | 0.124521 | 0.8 | IC.REF.Liq 1
3637932 | P0 | 0.000254 | 496.032 | 298.876 | Piping System: IC.REF.Liq | Level: P0 | 10 mmø | 0.155833 | 1 | IC.REF.Liq 1
3638013 | P0 | 0.000254 | 357.35 | 299.126 | Piping System: IC.REF.Liq | Level: P0 | 10 mmø | 0.112265 | 1 | IC.REF.Liq 1
3638025 | P0 | 0.000254 | 520.9 | 299.126 | Piping System: IC.REF.Liq | Level: P0 | 10 mmø | 0.163646 | 1 | IC.REF.Liq 1
3638036 | P0 | 0.000254 | 22.6068 | 299.126 | Piping System: IC.REF.Liq | Level: P0 | 10 mmø | 0.00710212 | 1 | IC.REF.Liq 1
3638241 | P0 | 0.000254 | 359.205 | 294.967 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø | 0.169271 | 1.5 | IC.REF.Gas 2
3638250 | P0 | 0.000254 | 531.203 | 294.828 | Piping System: IC.REF.Gas | Level: P0 | 18 mmø | 0.300388 | 1.8 | IC.REF.Gas 2
3638260 | P0 | 0.000254 | 337.15 | 294.4 | Piping System: IC.REF.Gas | Level: P0 | 22 mmø | 0.233022 | 2.2 | IC.REF.Gas 2
3638278 | P0 | 0.000254 | 57.0009 | 294.4 | Piping System: IC.REF.Gas | Level: P0 | 22 mmø | 0.0393962 | 2.2 | IC.REF.Gas 2
3638293 | P0 | 0.000254 | 243.675 | 294.689 | Piping System: IC.REF.Gas | Level: P0 | 20 mmø | 0.153106 | 2 | IC.REF.Gas 2
3638315 | P0 | 0.000254 | 128.87 | 294.967 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø | 0.0607286 | 1.5 | IC.REF.Gas 2
3638394 | P0 | 0.000254 | 493.505 | 294.967 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø | 0.232559 | 1.5 | IC.REF.Gas 2
3638427 | P0 | 0.000254 | 493.505 | 294.967 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø | 0.232559 | 1.5 | IC.REF.Gas 2
3638444 | P0 | 0.000254 | 493.505 | 294.967 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø | 0.232559 | 1.5 | IC.REF.Gas 2
3638487 | P0 | 0.000254 | 492.68 | 294.967 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø | 0.23217 | 1.5 | IC.REF.Gas 2
3638634 | P0 | 0.000254 | 354.245 | 294.967 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø | 0.166934 | 1.5 | IC.REF.Gas 2
3638719 | P0 | 0.000254 | 521.134 | 294.967 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø | 0.245578 | 1.5 | IC.REF.Gas 2
3638723 | P0 | 0.000254 | 57.6853 | 294.967 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø | 0.0271836 | 1.5 | IC.REF.Gas 2
3690340 | P0 | 0.000254 | 9.52883 | 70.944 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø | 0.00239486 | 0.8 | IC.REF.Liq 1
3690372 | P0 | 0.000254 | 6.35 | 71.717 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø | 0.00299237 | 1.5 | IC.REF.Gas 2
3690432 | P0 | 0.000254 | 2.96 | 78.6895 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø | 0.00185982 | 2 | IF.SANE.Fecal 2
3690688 | P0 | 0.000254 | 494.702 | 299.194 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø | 0.124332 | 0.8 | IC.REF.Liq 1
3690740 | P0 | 0.000254 | 10.6315 | 70.944 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø | 0.002672 | 0.8 | IC.REF.Liq 1
3690850 | P0 | 0.000254 | 9.52883 | 70.944 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø | 0.00239486 | 0.8 | IC.REF.Liq 1
3690852 | P0 | 0.000254 | 6.35 | 71.717 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø | 0.00299237 | 1.5 | IC.REF.Gas 2
3690854 | P0 | 0.000254 | 2.96 | 78.6895 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø | 0.00185982 | 2 | IF.SANE.Fecal 2
3690858 | P0 | 0.000254 | 12.9117 | 70.944 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø | 0.00324506 | 0.8 | IC.REF.Liq 1
3690878 | P0 | 0.000254 | 9.52883 | 70.944 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø | 0.00239486 | 0.8 | IC.REF.Liq 1
3690880 | P0 | 0.000254 | 6.35 | 71.717 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø | 0.00299237 | 1.5 | IC.REF.Gas 2
3690882 | P0 | 0.000254 | 2.96 | 78.6895 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø | 0.00185982 | 2 | IF.SANE.Fecal 2
3690886 | P0 | 0.000254 | 12.1279 | 70.944 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø | 0.00304808 | 0.8 | IC.REF.Liq 1
3690908 | P0 | 0.000254 | 9.52883 | 72.444 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø | 0.00239486 | 0.8 | IC.REF.Liq 1
3690910 | P0 | 0.000254 | 6.35 | 73.217 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø | 0.00299237 | 1.5 | IC.REF.Gas 2
3690912 | P0 | 0.000254 | 2.96 | 80.1895 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø | 0.00185982 | 2 | IF.SANE.Fecal 2
3690916 | P0 | 0.000254 | 16.3355 | 72.444 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø | 0.00410556 | 0.8 | IC.REF.Liq 1
3690998 | P0 | 0.000254 | 223.77 | 73.63 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø | 0.0562395 | 0.8 | IC.REF.Liq 1
3691136 | P0 | 0.000254 | 9.52883 | 70.944 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø | 0.00239486 | 0.8 | IC.REF.Liq 1
3691138 | P0 | 0.000254 | 6.35 | 71.717 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø | 0.00299237 | 1.5 | IC.REF.Gas 2
3691140 | P0 | 0.000254 | 2.96 | 78.6895 | Piping System: IF.SANE.Fecal | Level: P0 | 20 mmø | 0.00185982 | 2 | IF.SANE.Fecal 2
3691144 | P0 | 0.000254 | 16.9806 | 70.944 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø | 0.0042677 | 0.8 | IC.REF.Liq 1
3691159 | P0 | 0.000254 | 226.49 | 72.13 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø | 0.0569231 | 0.8 | IC.REF.Liq 1
3691201 | P0 | 0.000254 | 225.02 | 72.13 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø | 0.0565537 | 0.8 | IC.REF.Liq 1
3691359 | P0 | 0.000254 | 226.49 | 72.13 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø | 0.0569231 | 0.8 | IC.REF.Liq 1
3691443 | P0 | 0.000254 | 226.49 | 72.13 | Piping System: IC.REF.Liq | Level: P0 | 8 mmø | 0.0569231 | 0.8 | IC.REF.Liq 1
3691722 | P0 | 0.000254 | 218.45 | 75.4 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø | 0.102942 | 1.5 | IC.REF.Gas 2
3691728 | P0 | 0.000254 | 219.95 | 73.9 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø | 0.103649 | 1.5 | IC.REF.Gas 2
3691734 | P0 | 0.000254 | 219.95 | 73.9 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø | 0.103649 | 1.5 | IC.REF.Gas 2
3691740 | P0 | 0.000254 | 219.95 | 73.9 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø | 0.103649 | 1.5 | IC.REF.Gas 2
3691746 | P0 | 0.000254 | 219.95 | 73.9 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø | 0.103649 | 1.5 | IC.REF.Gas 2
3692078 | P0 | 0.000254 | 8.16238 | 294.967 | Piping System: IC.REF.Gas | Level: P0 | 15 mmø | 0.00384643 | 1.5 | IC.REF.Gas 2

# IfcFlowSegment: Pipe Types:AMB.GAS.Coure.ASTM B88_Type K (20)
Type - Pset_ProductRequirements - Category: Pipes
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.40.30.10; 105.AMB.ClassificacioDescripcio: Canalitzacions de subministrament de combustibles; 109.AMB.CodiTipus: GAS06; 111.AMB.DescripcioTipus: Tuberia coure
Classification: 50.40.30.10 Canalitzacions de subministrament de combustibles (Uniformat); Group: IG.Gas 2
Pset_DistributionFlowElementCommon - Reference: Pipe Types:AMB.GAS.Coure.ASTM B88_Type K; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.000254 cm
1 AMB.Identificacio - 107.AMB.NomTipus: Pipe Types: AMB.GAS.Coure.ASTM B88_Type K; 112.AMB.Servei: Piping System: IG.Gas; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 42 mmø
5 AMB.Geometria - 505.AMB.Diametre: 4.2 cm
Name (Pipe Types:AMB.GAS.Coure.ASTM B88_Type K:...) | In | Pset_FlowSegmentDuctSegment, Length (cm) = Pset_FlowSegmentPipeSegment, Length (cm) = 501.AMB.Longitud (cm) | InvertElevation (cm) | 115.AMB.Nivell | 507.AMB.Area (m2)
3594730 | P0 | 827.288 | -35.1 | Level: P0 | 1.09158
3594732 | P1 | 807.2 | -24.6 | Level: P1 | 1.06508
3601144 | P0 | 83.5372 | -35.1 | Level: P0 | 0.110225
3601228 | P2 | 2.5458 | 788.9 | Level: P2 | 0.0033591
3601244 | P2 | 907.46 | 758.9 | Level: P2 | 1.19737
3601295 | P2 | 610.836 | 758.9 | Level: P2 | 0.805979
3601357 | P2 | 110.018 | 642.582 | Level: P2 | 0.145166
3601415 | P2 | 27.0491 | 788.9 | Level: P2 | 0.0356905
3601483 | P2 | 13.2 | 769.4 | Level: P2 | 0.017417
3601702 | P1 | 61.7036 | 632.082 | Level: P1 | 0.081416
3610964 | P1 | 15.4 | 444.646 | Level: P1 | 0.0203198
3610981 | P1 | 11.6889 | 434.146 | Level: P1 | 0.0154232
3610991 | P1 | 181.136 | 444.646 | Level: P1 | 0.239003
3619190 | P1 | 11.6409 | 434.146 | Level: P1 | 0.0153598
3766284 | P0 | 77.5 | -35.1 | Level: P0 | 0.102259
3766296 | P0 | 99.2 | -24.6 | Level: P0 | 0.130891
3766306 | P0 | 2.15186 | 80.9 | Level: P0 | 0.00283931
3766316 | P0 | 99.2 | -24.6 | Level: P0 | 0.130891
3766522 | P0 | 0.525312 | 80.9 | Level: P0 | 0.000693134
3766693 | P0 | 10.2441 | 80.9 | Level: P0 | 0.0135167

# IfcFlowSegment: Pipe Types:AMB.LAM.Tuberia.PEX (168)
Type - Pset_ProductRequirements - Category: Pipes
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.30; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigua sanitària; 109.AMB.CodiTipus: LAM21; 111.AMB.DescripcioTipus: Tub de Polietilé reticulat PEX
Classification: 50.10.20.30 Canalitzacions d'aigua sanitària (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:AMB.LAM.Tuberia.PEX; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.000254 cm
1 AMB.Identificacio - 107.AMB.NomTipus: Pipe Types: AMB.LAM.Tuberia.PEX; 119.AMB.FaseCreacio: Obra
Name (Pipe Types:AMB.LAM.Tuberia.PEX:...) | In | Pset_FlowSegmentDuctSegment, Length (cm) = Pset_FlowSegmentPipeSegment, Length (cm) = 501.AMB.Longitud (cm) | InvertElevation (cm) | 112.AMB.Servei | 115.AMB.Nivell | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (cm) | Group
3359718 | P0 | 201.988 | 266.2 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.126913 | 2 | IF.FONT.AFS 5
3365782 | P0 | 22.4709 | 76.2 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0141189 | 2 | IF.FONT.AFS 5
3365783 | P0 | 186 | 79 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.116867 | 2 | IF.FONT.AFS 5
3365821 | P0 | 21.7848 | 76.2 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0136878 | 2 | IF.FONT.AFS 5
3365822 | P0 | 185.5 | 79 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.116553 | 2 | IF.FONT.AFS 5
3365860 | P0 | 21.2585 | 76.2 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0133571 | 2 | IF.FONT.AFS 5
3365861 | P0 | 185.5 | 79 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.116553 | 2 | IF.FONT.AFS 5
3365937 | P0 | 55.2972 | 266.2 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0347443 | 2 | IF.FONT.AFS 5
3365945 | P0 | 48.0973 | 266.2 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0302204 | 2 | IF.FONT.AFS 5
3366140 | P0 | 21.9898 | 76.2 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0138166 | 2 | IF.FONT.AFS 5
3366173 | P0 | 20.2766 | 76.2 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0127402 | 2 | IF.FONT.AFS 5
3366194 | P0 | 17.2092 | 76.2 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0108129 | 2 | IF.FONT.AFS 5
3366215 | P0 | 30.2753 | 76.2 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0190225 | 2 | IF.FONT.AFS 5
3366233 | P0 | 12.791 | 76.2 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.00803682 | 2 | IF.FONT.AFS 5
3366254 | P0 | 185 | 79.5 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.116239 | 2 | IF.FONT.AFS 5
3366257 | P0 | 19.6623 | 266.2 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0123542 | 2 | IF.FONT.AFS 5
3366289 | P0 | 185 | 79.5 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.116239 | 2 | IF.FONT.AFS 5
3366292 | P0 | 184.066 | 266.2 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.115652 | 2 | IF.FONT.AFS 5
3366317 | P0 | 180.8 | 79.5 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.1136 | 2 | IF.FONT.AFS 5
3366320 | P0 | 106.461 | 266 | Piping System: IF.FONT.AFS | Level: P0 | 25 mmø | 0.0836145 | 2.5 | IF.FONT.AFS 5
3369571 | P0 | 68.9542 | 266.2 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0433252 | 2 | IF.FONT.AFS 5
3369588 | P0 | 185.5 | 79 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.116553 | 2 | IF.FONT.AFS 5
3370922 | P0 | 18.3169 | 292.075 | Piping System: IF.FONT.AFS | Level: P0 | 32 mmø | 0.0184141 | 3.2 | IF.FONT.AFS 5
3370924 | P0 | 60.3824 | 266 | Piping System: IF.FONT.AFS | Level: P0 | 25 mmø | 0.0474242 | 2.5 | IF.FONT.AFS 5
3370953 | P0 | 255.373 | 266 | Piping System: IF.FONT.AFS | Level: P0 | 25 mmø | 0.200569 | 2.5 | IF.FONT.AFS 5
3370985 | P0 | 179.6 | 79.5 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.112846 | 2 | IF.FONT.AFS 5
3370988 | P0 | 218.693 | 265.7 | Piping System: IF.FONT.AFS | Level: P0 | 32 mmø | 0.219855 | 3.2 | IF.FONT.AFS 5
3371011 | P0 | 24.6027 | 292.075 | Piping System: IF.FONT.AFS | Level: P0 | 32 mmø | 0.0247333 | 3.2 | IF.FONT.AFS 5
3371149 | P0 | 213.902 | 291.95 | Piping System: IF.FONT.AFS | Level: P0 | 32 mmø | 0.215038 | 3.2 | IF.FONT.AFS 5
3371336 | P0 | 159.009 | 291 | Piping System: IF.FONT.AFS | Level: P0 | 50 mmø | 0.249772 | 5 | IF.FONT.AFS 5
3371358 | P0 | 17.2873 | 291 | Piping System: IF.FONT.AFS | Level: P0 | 50 mmø | 0.0271549 | 5 | IF.FONT.AFS 5
3371578 | P0 | 35.7009 | 292.45 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0224316 | 2 | IF.FONT.AFS 5
3371676 | P0 | 41.607 | 291.95 | Piping System: IF.FONT.AFS | Level: P0 | 32 mmø | 0.0418279 | 3.2 | IF.FONT.AFS 5
3371720 | P0 | 15.266 | 292.575 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.00959191 | 2 | IF.FONT.AFS 5
3371791 | P0 | 25.0131 | 292.45 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0157162 | 2 | IF.FONT.AFS 5
3371801 | P0 | 6.43874 | 76.2 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.00404558 | 2 | IF.FONT.AFS 5
3371802 | P0 | 211.75 | 79 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.133046 | 2 | IF.FONT.AFS 5
3371851 | P0 | 34.4241 | 295.2 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø | 0.0216293 | 2 | IF.FONT.ACS 2
3371888 | P0 | 30.6811 | 295.2 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø | 0.0192775 | 2 | IF.FONT.ACS 2
3374090 | P0 | 2.54 | 76.2 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø | 0.00159593 | 2 | IF.FONT.ACS 2
3374091 | P0 | 214.5 | 79 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø | 0.134774 | 2 | IF.FONT.ACS 2
3375687 | P0 | 36.0186 | 292.075 | Piping System: IF.FONT.AFS | Level: P0 | 32 mmø | 0.0362098 | 3.2 | IF.FONT.AFS 5
3375731 | P0 | 63.1618 | 292.45 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0396858 | 2 | IF.FONT.AFS 5
3375802 | P0 | 122.214 | 295.2 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø | 0.0767891 | 2 | IF.FONT.ACS 2
3700903 | P0 | 29.0115 | 291.5 | Piping System: IF.FONT.AFS | Level: P0 | 40 mmø | 0.036457 | 4 | IF.FONT.AFS 5
3700948 | P0 | 4.61917 | 291 | Piping System: IF.FONT.AFS | Level: P0 | 50 mmø | 0.00725578 | 5 | IF.FONT.AFS 5
3701028 | P0 | 174.499 | 291 | Piping System: IF.FONT.AFS | Level: P0 | 50 mmø | 0.274102 | 5 | IF.FONT.AFS 5
3701058 | P0 | 345.95 | 297.25 | Piping System: IF.FONT.AFS | Level: P0 | 40 mmø | 0.434734 | 4 | IF.FONT.AFS 5
3701495 | P0 | 315.25 | -27.1 | Piping System: IF.FONT.AFS | Level: P0 | 50 mmø | 0.495194 | 5 | IF.FONT.AFS 5
3703663 | P0 | 2146.08 | 291.95 | Piping System: IF.FONT.AFS | Level: P0 | 32 mmø | 2.15747 | 3.2 | IF.FONT.AFS 5
3703681 | P0 | 61.6529 | 292.45 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0387377 | 2 | IF.FONT.AFS 5
3703683 | P0 | 24.1334 | 295.2 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø | 0.0151634 | 2 | IF.FONT.ACS 2
3703720 | P0 | 76.1123 | 292.45 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0478227 | 2 | IF.FONT.AFS 5
3703722 | P0 | 55.5287 | 295.2 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø | 0.0348897 | 2 | IF.FONT.ACS 2
3703819 | P0 | 280.977 | 295.2 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø | 0.176543 | 2 | IF.FONT.ACS 2
3704087 | P0 | 21.1484 | 76.2 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0132879 | 2 | IF.FONT.AFS 5
3704115 | P0 | 21.6484 | 76.2 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0136021 | 2 | IF.FONT.AFS 5
3704133 | P0 | 33.2849 | 76.2 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0209135 | 2 | IF.FONT.AFS 5
3704153 | P0 | 21.0652 | 76.2 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0132357 | 2 | IF.FONT.AFS 5
3704171 | P0 | 33.6147 | 76.2 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0211207 | 2 | IF.FONT.AFS 5
3704196 | P0 | 28.2849 | 76.2 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø | 0.0177719 | 2 | IF.FONT.ACS 2
3704212 | P0 | 42.0001 | 76.2 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø | 0.0263895 | 2 | IF.FONT.ACS 2
3704316 | P0 | 6.91356 | 295.325 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø | 0.00434392 | 2 | IF.FONT.ACS 2
3704325 | P0 | 2.23133 | 295.325 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø | 0.00140198 | 2 | IF.FONT.ACS 2
3704334 | P0 | 214.625 | 79 | Piping System: IF.FONT.ACS | Level: P0 | 20 mmø | 0.134853 | 2 | IF.FONT.ACS 2
3704366 | P0 | 3.11179 | 292.575 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0019552 | 2 | IF.FONT.AFS 5
3704375 | P0 | 211.875 | 79 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.133125 | 2 | IF.FONT.AFS 5
3704426 | P0 | 114.113 | 292.45 | Piping System: IF.FONT.AFS | Level: P0 | 20 mmø | 0.0716995 | 2 | IF.FONT.AFS 5
