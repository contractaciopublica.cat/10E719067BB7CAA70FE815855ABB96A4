Properties of the parts of a building model (IFC2X3), part 1 of 7

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 903684/22
Time: 2023-08-09T13:08:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Alternate UI 22.0.2.392
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Aug 09 13:08:31 2023 * Host: DESKTOP-QUMTRDM * Database: C:\Users\Usuario\AppData\Local\Temp\8f24d1e0-fa72-4fe3-9172-47e25c6be9c8\cdab4f67-51e3-4432-98ad-03374f01919c\ifc * Database version: 5507 * Database creation date: Wed Aug 09 13:08:08 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Aug 09 13:08:08 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Aug 09 13:08:08 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 903684/22
LongName: Rehabilitació NZEB Hotel d'Entitats; Phase: Estat del Projecte
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 903684/22; 003.AMB.NomProjecte: Rehabilitació NZEB Hotel d'Entitats; 004.AMB.FaseProjecte: Estat del Projecte; 009.AMB.Municipi: MONTCADA I REIXAC

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 2637 cm
Pset_ProductRequirements - Category: Project Information
0 AMB.Informacio Projecte - 009.AMB.Municipi: MONTCADA I REIXAC

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 4
Pset_ProductRequirements - Category: Project Information
0 AMB.Informacio Projecte - 009.AMB.Municipi: MONTCADA I REIXAC

# IfcBuildingStorey: Level:AMB_Nivell (4)
Pset_ProductRequirements - Category: Levels
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name = 106.AMB.Nom | Elevation (cm)
S1 | S1 | -1.73259e-12
P0 | P0 | 17
P1 | P1 | 367
P2 | P2 | 721

# IfcBuildingElementProxy: AMB_Aire-condicionat_Paret_M02:AMB.CLI.AireCondicionat.DaikinTX50K (5)
In: P0
Type - Classification: 50.30.10.30 Unitats interiors d'instal·lacions tèrmiques (Uniformat); Material: Plástico.Blanco, Sistema.IC.AGUA.Fría.Impulsión
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.30; 105.AMB.ClassificacioDescripcio: Unitats interiors d'instal·lacions tèrmiques; 109.AMB.CodiTipus: CLI02; 111.AMB.DescripcioTipus: Aire condicionat Daikin TX50K
Type - 5 AMB.Geometria - 503.AMB.Altura: 73.5 cm
Material: Sistema.IC.AGUA.Fría.Impulsión, Sistema.IC.AGUA.Fría.Retorno, Elemento.Embocadura.SANE.Condensados, Plástico.Blanco; Group: IF.SANE.Fecal 2; IC.REF.Liq 1; IC.REF.Gas 2
Pset_BuildingElementProxyCommon - Reference: AMB_Aire-condicionat_Paret_M02:AMB.CLI.AireCondicionat.DaikinTX50K; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Aire-condicionat_Paret_M02: AMB.CLI.AireCondicionat.DaikinTX50K; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 221.AMB.CabalM3/h: 0 m3/s; 223.AMB.Pressio: 0 Pa
5 AMB.Geometria - 507.AMB.Area: 7.10683 m2; 509.AMB.Volum: 0.201003 m3
Name (AMB_Aire-condicionat_Paret_M02:AMB.CLI.AireCondicionat.DaikinTX50K:...)
3686096
3690849
3690877
3690907
3691135

# IfcBuildingElementProxy: AMB_ArmariComptador:AMB.GAS.ArmariComptador, AMB_ArmariComptador:AMB.GAS.ArmariComptador:3764906
In: P0
Type - Classification: 50.40.10.10 Equips de mesura, regulació i control de combustibles (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.40.10.10; 105.AMB.ClassificacioDescripcio: Equips de mesura, regulació i control de combustibles; 109.AMB.CodiTipus: GAS07; 111.AMB.DescripcioTipus: Armari comptador
Type - 5 AMB.Geometria - 503.AMB.Altura: 60 cm
Pset_BuildingElementProxyCommon - Reference: AMB_ArmariComptador:AMB.GAS.ArmariComptador; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_ArmariComptador: AMB.GAS.ArmariComptador; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 221.AMB.CabalM3/h: 0 m3/s; 222.AMB.VelocitatM/s: 0 m/s; 223.AMB.Pressio: 0 Pa
5 AMB.Geometria - 507.AMB.Area: 1.76214 m2; 509.AMB.Volum: 0.0150629 m3

# IfcBuildingElementProxy: AMB_CLI_Radiador_Jaga:AMB.CLI.RadiadorJaga Briza.950x140x550h mm (3)
Type - Classification: 50.30.10.30 Unitats interiors d'instal·lacions tèrmiques (Uniformat); Material: Metal.Aluminio.Satinado, Plastic.Polypropylene
Type - Pset_ManufacturerTypeInformation - Manufacturer: Jaga
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.30; 105.AMB.ClassificacioDescripcio: Unitats interiors d'instal·lacions tèrmiques; 109.AMB.CodiTipus: CLI13; 111.AMB.DescripcioTipus: Radiador Jaga Briza 950x140x550h mm
Type - 3 AMB.Fabricant - 301.AMB.Fabricant: Jaga; 302.AMB.Model: Radiador Jaga Briza - 950x140x550h mm
Type - 5 AMB.Geometria - 503.AMB.Altura: 55 cm
Material: Plastic.Polypropylene, <Unnamed>; Group: IC.AIGUA.Calenta.Retorn 3; IC.AIGUA.Calenta.Impulsió 3
Pset_BuildingElementProxyCommon - Reference: AMB_CLI_Radiador_Jaga:AMB.CLI.RadiadorJaga Briza.950x140x550h mm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_CLI_Radiador_Jaga: AMB.CLI.RadiadorJaga Briza.950x140x550h mm; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 221.AMB.CabalM3/h: 0 m3/s; 223.AMB.Pressio: 0 Pa
5 AMB.Geometria - 507.AMB.Area: 1.49681 m2; 509.AMB.Volum: 0.0693856 m3
Name (AMB_CLI_Radiador_Jaga:AMB.CLI.RadiadorJaga Briza.950x140x550h mm:...) | In | 115.AMB.Nivell
3662355 | P1 | Level: P1
3662395 | P1 | Level: P1
3662426 | P0 | Level: P0

# IfcBuildingElementProxy: AMB_CLI_Radiador_Jaga:AMB.CLI.RadiadorJagaTempo.500x150x700h mm, AMB_CLI_Radiador_Jaga:AMB.CLI.RadiadorJagaTempo.500x150x700h mm:3662508
In: P0
Type - Classification: 50.30.10.30 Unitats interiors d'instal·lacions tèrmiques (Uniformat); Material: Plastic.Polypropylene, Metal.Aluminio.Satinado
Type - Pset_ManufacturerTypeInformation - Manufacturer: Jaga
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.30; 105.AMB.ClassificacioDescripcio: Unitats interiors d'instal·lacions tèrmiques; 109.AMB.CodiTipus: CLI14; 111.AMB.DescripcioTipus: Radiador Jaga Tempo 500x150x700h mm
Type - 3 AMB.Fabricant - 301.AMB.Fabricant: Jaga; 302.AMB.Model: Radiador Jaga Tempo - 500x150x700h mm
Type - 5 AMB.Geometria - 503.AMB.Altura: 70 cm
Material: Plastic.Polypropylene, <Unnamed>; Group: IC.AIGUA.Calenta.Retorn 3; IC.AIGUA.Calenta.Impulsió 3
Pset_BuildingElementProxyCommon - Reference: AMB_CLI_Radiador_Jaga:AMB.CLI.RadiadorJagaTempo.500x150x700h mm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_CLI_Radiador_Jaga: AMB.CLI.RadiadorJagaTempo.500x150x700h mm; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 221.AMB.CabalM3/h: 0 m3/s; 223.AMB.Pressio: 0 Pa
5 AMB.Geometria - 507.AMB.Area: 0.934314 m2; 509.AMB.Volum: 0.0505356 m3

# IfcBuildingElementProxy: AMB_Caldera:AMB.CLI.Caldera.PrestigeSolo50, AMB_Caldera:AMB.CLI.Caldera.PrestigeSolo50:3601726
In: P1
Type - Classification: 50.30.10.40 Calderes (Uniformat); Material: Metal.Steel.Stainless.Brushed (4), Metal.Steel.Stainless, <Unnamed>
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.40; 105.AMB.ClassificacioDescripcio: Calderes; 109.AMB.CodiTipus: CLI03; 111.AMB.DescripcioTipus: Caldera Prestige
Type - 5 AMB.Geometria - 503.AMB.Altura: 100 cm
Pset_BuildingElementProxyCommon - Reference: AMB_Caldera:AMB.CLI.Caldera.PrestigeSolo50; sets with these values: 2
Pset_ProvisionForVoid - Width: 2.75386 cm; Height: 44 cm; Depth: 2.75386 cm
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Caldera: AMB.CLI.Caldera.PrestigeSolo50; 115.AMB.Nivell: Level: P1; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 221.AMB.CabalM3/h: 0 m3/s; 223.AMB.Pressio: 0 Pa
5 AMB.Geometria - 507.AMB.Area: 5.2402 m2; 509.AMB.Volum: 0.176337 m3
Group: Mechanical IC.AIRE.Extracció.Serveis 5; IC.AIGUA.Calenta.Retorn 3; IC.AIGUA.Calenta.Impulsió 3; IG.Gas 2

# IfcBuildingElementProxy: AMB_Central_Avisadors:AMB.PCI.CentralAvisadors, AMB_Central_Avisadors:AMB.PCI.CentralAvisadors:3574693
In: P0
Type - Classification: 50.50.20.10 Centraletes i racks de detecció d'incendis (Uniformat); Material: Plastic.Matte.Blue (2), Plastic.Epoxy·resin.White (3), Plastic.White (28)
Type - Pset_ProductRequirements - Category: Electrical Equipment
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.50.20.10; 105.AMB.ClassificacioDescripcio: Centraletes i racks de detecció d'incendis; 109.AMB.CodiTipus: PCI07; 111.AMB.DescripcioTipus: Centraleta incendis
Type - 2 AMB.Caracteristiques - 224.AMB.IP: IP44; 225.AMB.IK: IK04
Type - 5 AMB.Geometria - 503.AMB.Altura: 11 cm
Pset_BuildingElementProxyCommon - Reference: AMB_Central_Avisadors:AMB.PCI.CentralAvisadors; sets with these values: 2
Pset_ProvisionForVoid - Width: 0.5 cm; Height: 11 cm; Depth: 0.5 cm
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Central_Avisadors: AMB.PCI.CentralAvisadors; 113.AMB.IDCircuit: 1; 114.AMB.IDQuadre: AMB.PCI.CentraletaAvisadors; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 220.AMB.IntensitatMA: 0 W
5 AMB.Geometria - 507.AMB.Area: 0.0169468 m2; 509.AMB.Volum: 0.0000643094 m3

# IfcBuildingElementProxy: AMB_Centraleta_Incendis:AMB.PCI.CentraletaIncendis, AMB_Centraleta_Incendis:AMB.PCI.CentraletaIncendis:3399407
In: P0
Type - Classification: 50.50.20.10 Centraletes i racks de detecció d'incendis (Uniformat); Material: Plastic.Matte.Blue (2), Plastic.Epoxy·resin.White (3), Plastic.White (28)
Type - Pset_ProductRequirements - Category: Electrical Equipment
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.50.20.10; 105.AMB.ClassificacioDescripcio: Centraletes i racks de detecció d'incendis; 109.AMB.CodiTipus: PCI02; 111.AMB.DescripcioTipus: Centraleta incendis
Type - 2 AMB.Caracteristiques - 224.AMB.IP: IP44; 225.AMB.IK: IK04
Type - 5 AMB.Geometria - 503.AMB.Altura: 11 cm
Pset_BuildingElementProxyCommon - Reference: AMB_Centraleta_Incendis:AMB.PCI.CentraletaIncendis; sets with these values: 2
Pset_ProvisionForVoid - Width: 0.5 cm; Height: 11 cm; Depth: 0.5 cm
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Centraleta_Incendis: AMB.PCI.CentraletaIncendis; 113.AMB.IDCircuit: 1; 114.AMB.IDQuadre: AMB.PCI.CentraletaIncendis; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 220.AMB.IntensitatMA: 0 W
5 AMB.Geometria - 507.AMB.Area: 0.0169468 m2; 509.AMB.Volum: 0.0000643094 m3

# IfcBuildingElementProxy: AMB_Control_Gas:AMB.GAS.ControlGas, AMB_Control_Gas:AMB.GAS.ControlGas:3626406
In: P1
Type - Classification: 50.40.50.20 Detector de gasos (Uniformat); Material: Plastic.Matte.Blue (2), Plastic.Epoxy·resin.White (3), Plastic.White (28)
Type - Pset_ProductRequirements - Category: Electrical Equipment
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.40.50.20; 105.AMB.ClassificacioDescripcio: Detector de gasos; 109.AMB.CodiTipus: GAS02; 111.AMB.DescripcioTipus: Central gas
Type - 5 AMB.Geometria - 503.AMB.Altura: 11 cm
Pset_BuildingElementProxyCommon - Reference: AMB_Control_Gas:AMB.GAS.ControlGas; sets with these values: 2
Pset_ProvisionForVoid - Width: 0.5 cm; Height: 11 cm; Depth: 0.5 cm
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Control_Gas: AMB.GAS.ControlGas; 115.AMB.Nivell: Level: P1; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.0169468 m2; 509.AMB.Volum: 0.0000643094 m3

# IfcBuildingElementProxy: AMB_ELE_CGP:AMB.ELE.CaixaGeneralProteccio, AMB_ELE_CGP:AMB.ELE.CaixaGeneralProteccio:3766790
In: P0
Type - Classification: 50.60.10.10 Quadres elèctrics (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Electrical Equipment
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.10.10; 105.AMB.ClassificacioDescripcio: Quadres elèctrics; 109.AMB.CodiTipus: ELE13; 111.AMB.DescripcioTipus: Caixa protecció general (CGP)
Type - 3 AMB.Fabricant - 302.AMB.Model: Caixa General de Protecció
Type - 5 AMB.Geometria - 503.AMB.Altura: 47 cm
Pset_BuildingElementProxyCommon - Reference: AMB_ELE_CGP:AMB.ELE.CaixaGeneralProteccio; sets with these values: 2
Pset_ProvisionForVoid - Width: 47 cm; Height: 16 cm; Depth: 47 cm
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_ELE_CGP: AMB.ELE.CaixaGeneralProteccio; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.2579 m2; 509.AMB.Volum: 0.021808 m3

# IfcBuildingElementProxy: AMB_ELE_CaixaSeccionament:AMB.ELE.CaixaSeccionament, AMB_ELE_CaixaSeccionament:AMB.ELE.CaixaSeccionament:3766791
In: P0
Type - Classification: 50.60.10.10 Quadres elèctrics (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Electrical Equipment
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.10.10; 105.AMB.ClassificacioDescripcio: Quadres elèctrics; 109.AMB.CodiTipus: ELE14; 111.AMB.DescripcioTipus: Caixa seccionament (CS)
Type - 3 AMB.Fabricant - 302.AMB.Model: Caixa seccionament (CS)
Type - 5 AMB.Geometria - 503.AMB.Altura: 47 cm
Pset_BuildingElementProxyCommon - Reference: AMB_ELE_CaixaSeccionament:AMB.ELE.CaixaSeccionament; sets with these values: 2
Pset_ProvisionForVoid - Width: 47 cm; Height: 16 cm; Depth: 47 cm
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_ELE_CaixaSeccionament: AMB.ELE.CaixaSeccionament; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.2579 m2; 509.AMB.Volum: 0.021808 m3

# IfcBuildingElementProxy: AMB_ELE_TMF10:AMB.ELE.Comptadors.TMF10, AMB_ELE_TMF10:AMB.ELE.Comptadors.TMF10:3761847
In: P0
Type - Classification: 50.60.10.10 Quadres elèctrics (Uniformat); Material: Cristal (8), <Unnamed> (9)
Type - Pset_ProductRequirements - Category: Electrical Equipment
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.10.10; 105.AMB.ClassificacioDescripcio: Quadres elèctrics; 109.AMB.CodiTipus: ELE12; 111.AMB.DescripcioTipus: Armari comptadors electrics (TMF10)
Type - 3 AMB.Fabricant - 302.AMB.Model: Quadre de comptadors TMF10
Type - 5 AMB.Geometria - 503.AMB.Altura: 144 cm
Pset_BuildingElementProxyCommon - Reference: AMB_ELE_TMF10:AMB.ELE.Comptadors.TMF10; sets with these values: 2
Pset_ProvisionForVoid - Width: 17.1 cm; Height: 27 cm; Depth: 17.1 cm
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_ELE_TMF10: AMB.ELE.Comptadors.TMF10; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 4.33544 m2; 509.AMB.Volum: 0.0484401 m3

# IfcBuildingElementProxy: AMB_Extractor_CAB_S&P:AMB.CLI.Extractor.CAB-125 (230V 50/60) R8 (6)
Type - Classification: 50.30.10.80 Ventiladors (Uniformat); Material: Plástico, moldeado negro, Acero Galvanizado (11)
Type - Pset_ManufacturerOccurrence - SerialNumber: 0
Type - Pset_ManufacturerTypeInformation - ArticleNumber: 0; Manufacturer: S&P Sistemas de Ventilación S.L.U.
Type - Pset_PrecastConcreteElementGeneral - SerialNumber: 0
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Type - Pset_Warranty - IsExtendedWarranty: no
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.80; 105.AMB.ClassificacioDescripcio: Ventiladors; 109.AMB.CodiTipus: CLI08; 111.AMB.DescripcioTipus: Extractor CAB-125
Type - 3 AMB.Fabricant - 301.AMB.Fabricant: S&P Sistemas de Ventilación S.L.U.; 302.AMB.Model: 0
Pset_BuildingElementProxyCommon - Reference: AMB_Extractor_CAB_S&P:AMB.CLI.Extractor.CAB-125 (230V 50/60) R8; sets with these values: 2
Pset_ManufacturerOccurrence - sets with these values: 2
Pset_ProvisionForVoid - Width: 0.245033 cm; Depth: 0.245033 cm
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Extractor_CAB_S&P: AMB.CLI.Extractor.CAB-125 (230V 50/60) R8; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 221.AMB.CabalM3/h: 0 m3/s; 223.AMB.Pressio: 0 Pa
5 AMB.Geometria - 507.AMB.Area: 0.416656 m2; 509.AMB.Volum: 0.0420677 m3
Name (AMB_Extractor_CAB_S&P:AMB.CLI.Extractor.CAB-125 (230V 50/60) R8:...) | In | Height (cm) | 115.AMB.Nivell | Group | Material
3482835 | P0 | 39.5 | Level: P0 | Mechanical IC.AIRE.Extracció.Serveis 3
3484387 | P0 | 38.8 | Level: P0 | Mechanical IC.AIRE.Extracció.Serveis 2
3484757 | P0 | 38.8 | Level: P0 | Mechanical IC.AIRE.Extracció.Serveis 4 | Plástico, moldeado negro, Acero Galvanizado
3658210 | P1 | 39.5 | Level: P1 | Mechanical IC.AIRE.Extracció.Serveis 6 | Plástico, moldeado negro, Acero Galvanizado
3695405 | P1 | 39.5 | Level: P1 | Mechanical IC.AIRE.Extracció.Serveis 9 | Plástico, moldeado negro, Acero Galvanizado
3696901 | P0 | 39.5 | Level: P0 | Mechanical IC.AIRE.Extracció.Serveis 11 | Plástico, moldeado negro, Acero Galvanizado

# IfcBuildingElementProxy: AMB_Extractor_CAB_S&P:AMB.CLI.Extractor.CAB-160 (230V 50/60) R8, AMB_Extractor_CAB_S&P:AMB.CLI.Extractor.CAB-160 (230V 50/60) R8:3482859
In: P0
Type - Classification: 50.30.10.80 Ventiladors (Uniformat); Material: Plástico, moldeado negro, Acero Galvanizado (11)
Type - Pset_ManufacturerOccurrence - SerialNumber: 0
Type - Pset_ManufacturerTypeInformation - ArticleNumber: 0; Manufacturer: S&P Sistemas de Ventilación S.L.U.
Type - Pset_PrecastConcreteElementGeneral - SerialNumber: 0
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Type - Pset_Warranty - IsExtendedWarranty: no
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.80; 105.AMB.ClassificacioDescripcio: Ventiladors; 109.AMB.CodiTipus: CLI09; 111.AMB.DescripcioTipus: Extractor CAB-160
Type - 3 AMB.Fabricant - 301.AMB.Fabricant: S&P Sistemas de Ventilación S.L.U.; 302.AMB.Model: 0
Pset_BuildingElementProxyCommon - Reference: AMB_Extractor_CAB_S&P:AMB.CLI.Extractor.CAB-160 (230V 50/60) R8; sets with these values: 2
Pset_ManufacturerOccurrence - sets with these values: 2
Pset_ProvisionForVoid - Width: 0.245033 cm; Height: 39.5 cm; Depth: 0.245033 cm
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Extractor_CAB_S&P: AMB.CLI.Extractor.CAB-160 (230V 50/60) R8; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 221.AMB.CabalM3/h: 0 m3/s; 223.AMB.Pressio: 0 Pa
5 AMB.Geometria - 507.AMB.Area: 0.42985 m2; 509.AMB.Volum: 0.0421282 m3
Group: Mechanical IC.AIRE.Extracció.Serveis 1

# IfcBuildingElementProxy: AMB_Hidrant:AMB.PCI.Hidrant, AMB_Hidrant:AMB.PCI.Hidrant:3412135
In: P0
Type - Classification: 50.50.10.40 Dispositius d'extinció d'incendis (Uniformat); Material: Metal.Bronce.ASTM-B62, Plástico.EPDM.Negro, Metal.Hierro·Dúctil.Pintado.Mate.Rojo
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.50.10.40; 105.AMB.ClassificacioDescripcio: Dispositius d'extinció d'incendis; 109.AMB.CodiTipus: PCI03; 111.AMB.DescripcioTipus: Hidrant
Type - 5 AMB.Geometria - 503.AMB.Altura: 80.49 cm
Material: Metal.Bronce.ASTM-B62, Metal.Hierro·Dúctil.Pintado.Mate.Rojo, Plástico.EPDM.Negro
Pset_BuildingElementProxyCommon - Reference: AMB_Hidrant:AMB.PCI.Hidrant; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Hidrant: AMB.PCI.Hidrant; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 1.10897 m2; 509.AMB.Volum: 0.0545898 m3

# IfcBuildingElementProxy: AMB_InversorFotovoltaic:AMB.ELE.InversorFotovoltaic, AMB_InversorFotovoltaic:AMB.ELE.InversorFotovoltaic:3562528
In: P2
Type - Classification: 50.60.70.10 Captadors solars fotovoltaics (Uniformat); Material: Cloruro de polivinilo, rígido negro, Cloruro de polivinilo, rígido rojo, Acero inoxidable AISI 304
Type - Pset_ManufacturerTypeInformation - Manufacturer: SMA Solar Technology AG
Type - Pset_ProductRequirements - Category: Electrical Equipment
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.70.10; 105.AMB.ClassificacioDescripcio: Captadors solars fotovoltaics; 109.AMB.CodiTipus: ELE01; 111.AMB.DescripcioTipus: Inversor fotovoltaic
Type - 3 AMB.Fabricant - 301.AMB.Fabricant: SMA Solar Technology AG; 302.AMB.Model: Inversor SMA Sunny Boy 1.5
Type - 5 AMB.Geometria - 503.AMB.Altura: 35.7 cm
Material: Acero inoxidable AISI 304, Panel LED autoiluminado azul, Panel LED autoiluminado blanco, Panel LED autoiluminado verde, Cloruro de polivinilo, rígido negro, Cloruro de polivinilo, rígido rojo
Pset_BuildingElementProxyCommon - Reference: AMB_InversorFotovoltaic:AMB.ELE.InversorFotovoltaic; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_InversorFotovoltaic: AMB.ELE.InversorFotovoltaic; 113.AMB.IDCircuit: N/A; 114.AMB.IDQuadre: QUADRE GENERAL (QGBT); 115.AMB.Nivell: Level: P2; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.274989 m2; 509.AMB.Volum: 0.0201698 m3

# IfcBuildingElementProxy: AMB_Panells_Solars:AMB.ELE.PanellsSolars (2)
In: S1
Type - Classification: 50.60.70.10 Captadors solars fotovoltaics (Uniformat); Material: <Unnamed> (18)
Type - Pset_ProductRequirements - Category: Electrical Equipment
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.70.10; 105.AMB.ClassificacioDescripcio: Captadors solars fotovoltaics; 109.AMB.CodiTipus: ELE08; 111.AMB.DescripcioTipus: Panells solars
Pset_BuildingElementProxyCommon - Reference: AMB_Panells_Solars:AMB.ELE.PanellsSolars; sets with these values: 2
Pset_ProvisionForVoid - Width: 1 cm; Height: 140 cm; Depth: 1 cm
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Panells_Solars: AMB.ELE.PanellsSolars; 113.AMB.IDCircuit: N/A; 114.AMB.IDQuadre: QUADRE GENERAL (QGBT); 115.AMB.Nivell: Level: S1; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 32.527 m2; 509.AMB.Volum: 1.97318 m3
Name (AMB_Panells_Solars:AMB.ELE.PanellsSolars:...)
3561435
3561436 | Material: <Unnamed>

# IfcBuildingElementProxy: AMB_Quadre_Subquadre_Força_Enllumenat:AMB.ELE.QUA.Quadre Planta Baixa (QPB), AMB_Quadre_Subquadre_Força_Enllumenat:AMB.ELE.QUA.Quadre Planta Baixa (QPB):3746210
In: P0
Type - Classification: 50.60.20.20 Quadres de comandament elèctric (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Electrical Equipment
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.20.20; 105.AMB.ClassificacioDescripcio: Quadres de comandament elèctric; 109.AMB.CodiTipus: ELE02; 111.AMB.DescripcioTipus: Quadre Planta Baixa (QPB)
Type - 5 AMB.Geometria - 503.AMB.Altura: 55 cm
Pset_BuildingElementProxyCommon - Reference: AMB_Quadre_Subquadre_Força_Enllumenat:AMB.ELE.QUA.Quadre Planta Baixa (QPB); sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Quadre_Subquadre_Força_Enllumenat: AMB.ELE.QUA.Quadre Planta Baixa (QPB); 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 2.30062 m2; 509.AMB.Volum: 0.10133 m3

# IfcBuildingElementProxy: AMB_Quadre_Subquadre_Força_Enllumenat:AMB.ELE.QUA.Subquadre Planta Coberta FV (QFV), AMB_Quadre_Subquadre_Força_Enllumenat:AMB.ELE.QUA.Subquadre Planta Coberta FV (QFV):3746279
In: P2
Type - Classification: 50.60.20.20 Quadres de comandament elèctric (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Electrical Equipment
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.20.20; 105.AMB.ClassificacioDescripcio: Quadres de comandament elèctric; 109.AMB.CodiTipus: ELE03; 111.AMB.DescripcioTipus: Subquadre Planta Coberta FV (QFV)
Type - 5 AMB.Geometria - 503.AMB.Altura: 55 cm
Pset_BuildingElementProxyCommon - Reference: AMB_Quadre_Subquadre_Força_Enllumenat:AMB.ELE.QUA.Subquadre Planta Coberta FV (QFV); sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Quadre_Subquadre_Força_Enllumenat: AMB.ELE.QUA.Subquadre Planta Coberta FV (QFV); 115.AMB.Nivell: Level: P2; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 1.11262 m2; 509.AMB.Volum: 0.04358 m3

# IfcBuildingElementProxy: AMB_Quadre_Subquadre_Força_Enllumenat:AMB.ELE.QUA.Subquadre Planta Primera (QPP), AMB_Quadre_Subquadre_Força_Enllumenat:AMB.ELE.QUA.Subquadre Planta Primera (QPP):3746381
In: P1
Type - Classification: 50.60.20.20 Quadres de comandament elèctric (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Electrical Equipment
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.20.20; 105.AMB.ClassificacioDescripcio: Quadres de comandament elèctric; 109.AMB.CodiTipus: ELE05; 111.AMB.DescripcioTipus: Subquadre Planta Primera (QPP)
Type - 5 AMB.Geometria - 503.AMB.Altura: 55 cm
Pset_BuildingElementProxyCommon - Reference: AMB_Quadre_Subquadre_Força_Enllumenat:AMB.ELE.QUA.Subquadre Planta Primera (QPP); sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Quadre_Subquadre_Força_Enllumenat: AMB.ELE.QUA.Subquadre Planta Primera (QPP); 115.AMB.Nivell: Level: P1; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 2.30062 m2; 509.AMB.Volum: 0.10133 m3

# IfcBuildingElementProxy: AMB_Quadre_Subquadre_Força_Enllumenat:AMB.ELE.QUA.Subquadre Planta Primera Calefacció (QCA), AMB_Quadre_Subquadre_Força_Enllumenat:AMB.ELE.QUA.Subquadre Planta Primera Calefacció (QCA):3746324
In: P1
Type - Classification: 50.60.20.20 Quadres de comandament elèctric (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Electrical Equipment
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.20.20; 105.AMB.ClassificacioDescripcio: Quadres de comandament elèctric; 109.AMB.CodiTipus: ELE04; 111.AMB.DescripcioTipus: Subquadre Planta Primera Calefacció (QCA)
Type - 5 AMB.Geometria - 503.AMB.Altura: 55 cm
Pset_BuildingElementProxyCommon - Reference: AMB_Quadre_Subquadre_Força_Enllumenat:AMB.ELE.QUA.Subquadre Planta Primera Calefacció (QCA); sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Quadre_Subquadre_Força_Enllumenat: AMB.ELE.QUA.Subquadre Planta Primera Calefacció (QCA); 115.AMB.Nivell: Level: P1; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 1.40962 m2; 509.AMB.Volum: 0.0580175 m3

# IfcBuildingElementProxy: AMB_Recuperador-calor_Fix-creuat_Aigua:AMB.CLI.Recuperador.RCA - V - 2800 (2)
Type - Classification: 50.30.10.90 Recuperadors (Uniformat); Material: Auxiliar.Negro (2), Auxiliar.Amarillo, Auxiliar.Blanco, Metal.Acero.Galvanizado (12)
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.90; 105.AMB.ClassificacioDescripcio: Recuperadors; 109.AMB.CodiTipus: CLI18; 111.AMB.DescripcioTipus: Recuperador calor
Type - 5 AMB.Geometria - 503.AMB.Altura: 45 cm
Pset_BuildingElementProxyCommon - Reference: AMB_Recuperador-calor_Fix-creuat_Aigua:AMB.CLI.Recuperador.RCA - V - 2800; sets with these values: 2
Pset_ProvisionForVoid - Width: 45 cm; Height: 120 cm; Depth: 45 cm
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Recuperador-calor_Fix-creuat_Aigua: AMB.CLI.Recuperador.RCA - V - 2800; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 221.AMB.CabalM3/h: 0 m3/s; 223.AMB.Pressio: 0 Pa
5 AMB.Geometria - 507.AMB.Area: 17.3356 m2; 509.AMB.Volum: 0.666514 m3
Name (AMB_Recuperador-calor_Fix-creuat_Aigua:AMB.CLI.Recuperador.RCA - V - 2800:...) | In | 115.AMB.Nivell | Group
3454878 | P0 | Level: P0 | Mechanical IC.AIRE.ExtraccióPrimari 2; Mechanical IC.AIRE.ExtraccióPrimari 3; Mechanical IC.AIRE.Aportació 4; Mechanical IC.AIRE.Aportació 5
3697058 | P1 | Level: P1 | Mechanical IC.AIRE.Aportació 2; Mechanical IC.AIRE.ExtraccióPrimari 1; Mechanical IC.AIRE.ExtraccióPrimari 4; Mechanical IC.AIRE.Aportació 3 | Material: Auxiliar.Negro, Auxiliar.Amarillo, Auxiliar.Blanco, Metal.Acero.Galvanizado

# IfcBuildingElementProxy: AMB_Sensor_Crepuscular:AMB.ELE.Sensor.Crepuscular.Sostre (8)
Type - Classification: 50.60.40.10 Mecanismes (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Lighting Devices
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.40.10; 105.AMB.ClassificacioDescripcio: Mecanismes; 109.AMB.CodiTipus: ELE06; 111.AMB.DescripcioTipus: Sensor crepuscular
Pset_BuildingElementProxyCommon - Reference: AMB_Sensor_Crepuscular:AMB.ELE.Sensor.Crepuscular.Sostre; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Sensor_Crepuscular: AMB.ELE.Sensor.Crepuscular.Sostre; 113.AMB.IDCircuit: N/A; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 206.AMB.AcabatSuperficial: Plàstic ABS
5 AMB.Geometria - 507.AMB.Area: 0.0119201 m2; 509.AMB.Volum: 0.000113215 m3
Name (AMB_Sensor_Crepuscular:AMB.ELE.Sensor.Crepuscular.Sostre:...) | In | 114.AMB.IDQuadre | 115.AMB.Nivell
3751295 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3753531 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3753540 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3753621 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3753634 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3753642 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3753652 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3753677 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1

# IfcBuildingElementProxy: AMB_Termo_50L:AMB.LAM.Termo.LAGO_EV_50 (2)
Type - Classification: 50.30.10.50 Termoacumuladors (Uniformat); Material: Nuovo materiale di default
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.50; 105.AMB.ClassificacioDescripcio: Termoacumuladors; 109.AMB.CodiTipus: LAM07; 111.AMB.DescripcioTipus: Termo Elèctric
Type - 3 AMB.Fabricant - 302.AMB.Model: LAGO EV 50
Material: Nuovo materiale di default, colonne, corpo, Materiale per il rendering 165-0-0, <Unnamed>
Pset_BuildingElementProxyCommon - Reference: AMB_Termo_50L:AMB.LAM.Termo.LAGO_EV_50; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Termo_50L: AMB.LAM.Termo.LAGO_EV_50; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 221.AMB.CabalM3/h: 0 m3/s; 222.AMB.VelocitatM/s: 0 m/s; 223.AMB.Pressio: 0 Pa
5 AMB.Geometria - 507.AMB.Area: 0.934426 m2; 509.AMB.Volum: 0.0837986 m3
Name (AMB_Termo_50L:AMB.LAM.Termo.LAGO_EV_50:...) | In | 115.AMB.Nivell | Group
3705201 | P0 | Level: P0 | IF.FONT.ACS 2; IF.FONT.AFS 5
3710543 | P1 | Level: P1 | IF.FONT.ACS 4; IF.FONT.AFS 5

# IfcBuildingElementProxy: AMB_Unitat exterior_3Tubs_1Mòdul:AMB.CLI.UnitatExterior.REYQ6T, AMB_Unitat exterior_3Tubs_1Mòdul:AMB.CLI.UnitatExterior.REYQ6T:3437729
In: P2
Type - Classification: 50.30.10.20 Unitats exteriors d'instal·lacions tèrmiques (Uniformat); Material: <Unnamed>, Metal.Steel.Galvanized, Auxiliary.Clearance, Metal.Steel.Chrome·plated, System.IC.SPLT.Gas
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.20; 105.AMB.ClassificacioDescripcio: Unitats exteriors d'instal·lacions tèrmiques; 109.AMB.CodiTipus: CLI01; 111.AMB.DescripcioTipus: Unitat exterior clima
Type - 5 AMB.Geometria - 503.AMB.Altura: 168.5 cm
Material: System.IC.SPLT.Gas, Metal.Steel.Galvanized, System.IC.SPLT.Liquid, Metal.Steel.Chrome·plated, <Unnamed>; Group: IC.REF.Gas 1; IC.REF.Liq 1; IC.REF.Gas 2
Pset_BuildingElementProxyCommon - Reference: AMB_Unitat exterior_3Tubs_1Mòdul:AMB.CLI.UnitatExterior.REYQ6T; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Unitat exterior_3Tubs_1Mòdul: AMB.CLI.UnitatExterior.REYQ6T; 115.AMB.Nivell: Level: P2; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 221.AMB.CabalM3/h: 0 m3/s; 223.AMB.Pressio: 0 Pa
5 AMB.Geometria - 507.AMB.Area: 22.3562 m2; 509.AMB.Volum: 1.1482 m3

# IfcDistributionControlElement: AMB_Avisador_Emergencia:AMB.PCI.Avisador.Emergencia (9)
Type - Classification: 50.90.50.40 Altres dispositius de maniobra i control especials (Uniformat); Material: <Unnamed> (3)
Type - Pset_ProductRequirements - Category: Fire Alarm Devices
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.90.50.40; 105.AMB.ClassificacioDescripcio: Altres dispositius de maniobra i control especials; 109.AMB.CodiTipus: PCI06; 111.AMB.DescripcioTipus: Avisador Emergencia
Type - 5 AMB.Geometria - 503.AMB.Altura: 15 cm
Pset_QuantityTakeOff - Reference: AMB_Avisador_Emergencia:AMB.PCI.Avisador.Emergencia
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Avisador_Emergencia: AMB.PCI.Avisador.Emergencia; 113.AMB.IDCircuit: 1; 114.AMB.IDQuadre: AMB.PCI.CentraletaAvisadors; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.060334 m2; 509.AMB.Volum: 0.000613175 m3
Name (AMB_Avisador_Emergencia:AMB.PCI.Avisador.Emergencia:...) | In | 115.AMB.Nivell | Material
3529820 | P0 | Level: P0
3529876 | P0 | Level: P0 | <Unnamed>
3529882 | P0 | Level: P0 | <Unnamed>
3529965 | P0 | Level: P0 | <Unnamed>
3530071 | P0 | Level: P0 | <Unnamed>
3530405 | P1 | Level: P1 | <Unnamed>
3530426 | P1 | Level: P1 | <Unnamed>
3530549 | P1 | Level: P1 | <Unnamed>
3530625 | P1 | Level: P1 | <Unnamed>

# IfcDistributionControlElement: AMB_Detector_Fums òptic_BC:AMB.PCI.Detector.FumsOptic (42)
Type - Classification: 50.50.30.30 Detectors d'incendis (Uniformat); Material: Plastic.White
Type - Pset_ProductRequirements - Category: Fire Alarm Devices
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.50.30.30; 105.AMB.ClassificacioDescripcio: Detectors d'incendis; 109.AMB.CodiTipus: PCI09; 111.AMB.DescripcioTipus: Detector de fums òptic segons UNE-EN 54-7
Type - 2 AMB.Caracteristiques - 224.AMB.IP: IP44; 225.AMB.IK: IK04
Type - 5 AMB.Geometria - 503.AMB.Altura: 4.5 cm
Pset_QuantityTakeOff - Reference: AMB_Detector_Fums òptic_BC:AMB.PCI.Detector.FumsOptic
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Detector_Fums òptic_BC: AMB.PCI.Detector.FumsOptic; 113.AMB.IDCircuit: 1; 114.AMB.IDQuadre: AMB.PCI.CentraletaIncendis; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.0246875 m2; 509.AMB.Volum: 0.000332073 m3
Name (AMB_Detector_Fums òptic_BC:AMB.PCI.Detector.FumsOptic:...) | In | 115.AMB.Nivell
3378262 | P0 | Level: P0
3378322 | P0 | Level: P0
3378331 | P0 | Level: P0
3378346 | P0 | Level: P0
3378356 | P0 | Level: P0
3378432 | P0
3378455 | P0
3378478 | P0 | Level: P0
3378486 | P0 | Level: P0
3378494 | P0 | Level: P0
3378601 | P0 | Level: P0
3378670 | P0 | Level: P0
3378748 | P0 | Level: P0
3378766 | P0 | Level: P0
3378807 | P0 | Level: P0
3378839 | P0 | Level: P0
3378871 | P0 | Level: P0
3378879 | P0 | Level: P0
3378892 | P0 | Level: P0
3378929 | P0 | Level: P0
3379036 | P0 | Level: P0
3379070 | P0 | Level: P0
3379144 | P0 | Level: P0
3379166 | P0 | Level: P0
3379238 | P1 | Level: P1
3379281 | P1 | Level: P1
3379298 | P1 | Level: P1
3379308 | P1 | Level: P1
3379316 | P1 | Level: P1
3379372 | P1 | Level: P1
3379428 | P1 | Level: P1
3379455 | P1 | Level: P1
3379464 | P1 | Level: P1
3379472 | P1 | Level: P1
3379494 | P1 | Level: P1
3379495 | P1 | Level: P1
3379516 | P1 | Level: P1
3379524 | P1 | Level: P1
3531040 | P1 | Level: P1
3531055 | P0 | Level: P0
3531123 | P1 | Level: P1
3531172 | P1 | Level: P1

# IfcDistributionControlElement: AMB_Extintor_Armari:AMB.PCI.ExtintorABC.6 kg(21a113b) (7)
Type - Classification: 50.50.10.80 Extintors (Uniformat); Material: Plastic.Matte.Black
Type - Pset_ProductRequirements - Category: Fire Alarm Devices
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.50.10.80; 105.AMB.ClassificacioDescripcio: Extintors; 109.AMB.CodiTipus: PCI04; 111.AMB.DescripcioTipus: Extintor manual de pols seca polivalent, de càrrega 6 kg, amb pressió incorporada, pintat, amb suport a paret
Type - 2 AMB.Caracteristiques - 224.AMB.IP: N/A; 225.AMB.IK: N/A
Material: Plastic.Matte.Black, Metal.Steel.Carbon.Painted.Matte.Red, Metal.Brass, Metal.Steel.Stainless
Pset_QuantityTakeOff - Reference: AMB_Extintor_Armari:AMB.PCI.ExtintorABC.6 kg(21a113b)
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Extintor_Armari: AMB.PCI.ExtintorABC.6 kg(21a113b); 113.AMB.IDCircuit: N/A; 114.AMB.IDQuadre: N/A; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.305812 m2; 509.AMB.Volum: 0.016609 m3
Name (AMB_Extintor_Armari:AMB.PCI.ExtintorABC.6 kg(21a113b):...) | In | 115.AMB.Nivell
3499013 | P0 | Level: P0
3511951 | P0 | Level: P0
3512029 | P1 | Level: P1
3512059 | P1 | Level: P1
3512080 | P1 | Level: P1
3512197 | P1 | Level: P1
3746823 | P0

# IfcDistributionControlElement: AMB_Extintor_Armari:AMB.PCI.ExtintorCO2.5Kg (4)
Type - Classification: 50.50.10.80 Extintors (Uniformat); Material: Plastic.Matte.Black
Type - Pset_ProductRequirements - Category: Fire Alarm Devices
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.50.10.80; 105.AMB.ClassificacioDescripcio: Extintors; 109.AMB.CodiTipus: PCI10; 111.AMB.DescripcioTipus: Extintor manual de diòxid de carboni, de càrrega 5kg, amb pressió incorporada, pintat, a,mb suport a paret
Type - 2 AMB.Caracteristiques - 224.AMB.IP: N/A; 225.AMB.IK: N/A
Material: Plastic.Matte.Black, Metal.Steel.Carbon.Painted.Matte.Red, Metal.Brass, Metal.Steel.Stainless
Pset_QuantityTakeOff - Reference: AMB_Extintor_Armari:AMB.PCI.ExtintorCO2.5Kg
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Extintor_Armari: AMB.PCI.ExtintorCO2.5Kg; 113.AMB.IDCircuit: N/A; 114.AMB.IDQuadre: N/A; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.394903 m2; 509.AMB.Volum: 0.0247095 m3
Name (AMB_Extintor_Armari:AMB.PCI.ExtintorCO2.5Kg:...) | In | 115.AMB.Nivell
3498984 | P0 | Level: P0
3512272 | P1 | Level: P1
3512284 | P1 | Level: P1
3746822 | P0

# IfcDistributionControlElement: AMB_Polsador_Manual:AMB.PCI.PolsadorManual (5)
Type - Classification: 50.50.30.10 Polsadors (Uniformat); Material: Plastic.Matte.Black
Type - Pset_ProductRequirements - Category: Fire Alarm Devices
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.50.30.10; 105.AMB.ClassificacioDescripcio: Polsadors; 109.AMB.CodiTipus: PCI08; 111.AMB.DescripcioTipus: Polsador manual
Type - 2 AMB.Caracteristiques - 224.AMB.IP: IP44; 225.AMB.IK: IK04
Type - 5 AMB.Geometria - 503.AMB.Altura: 15 cm
Material: Plastic.Matte.Black, Plastic.Glossy.Red
Pset_QuantityTakeOff - Reference: AMB_Polsador_Manual:AMB.PCI.PolsadorManual
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Polsador_Manual: AMB.PCI.PolsadorManual; 113.AMB.IDCircuit: 1; 114.AMB.IDQuadre: AMB.PCI.CentraletaIncendis; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.03468 m2; 509.AMB.Volum: 0.0007264 m3
Name (AMB_Polsador_Manual:AMB.PCI.PolsadorManual:...) | In | 115.AMB.Nivell
3382530 | P0 | Level: P0
3486026 | P0 | Level: P0
3486086 | P1 | Level: P1
3486088 | P1 | Level: P1
3779386 | P0 | Level: P0

# IfcDistributionControlElement: AMB_Sensor_Gas:AMB.GAS.Sensor.Gas (2)
In: P1
Type - Classification: 50.40.50.20 Detector de gasos (Uniformat); Material: Plastic.White
Type - Pset_ProductRequirements - Category: Fire Alarm Devices
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.40.50.20; 105.AMB.ClassificacioDescripcio: Detector de gasos; 109.AMB.CodiTipus: GAS05; 111.AMB.DescripcioTipus: Sensor gas
Type - 5 AMB.Geometria - 503.AMB.Altura: 4.5 cm
Pset_QuantityTakeOff - Reference: AMB_Sensor_Gas:AMB.GAS.Sensor.Gas
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Sensor_Gas: AMB.GAS.Sensor.Gas; 115.AMB.Nivell: Level: P1; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.0246875 m2; 509.AMB.Volum: 0.000332073 m3
Name (AMB_Sensor_Gas:AMB.GAS.Sensor.Gas:...)
3621498
3621519

# IfcDistributionPort (3289)
Description: Flow
Name | FlowDirection | Group
Port_3305042 | SOURCE
Port_3305042 | SOURCEANDSINK
Port_3305049 | SOURCE
Port_3305056 | SOURCE
InPort_3309852 | SINK | IF.SANE.Pluvial 3
OutPort_3309747 | SOURCE | IF.SANE.Pluvial 3
InPort_3543835 | SINK | IF.SANE.Pluvial 3
OutPort_3309852 | SOURCE | IF.SANE.Pluvial 3
InPort_3309889 | SINK | IF.SANE.Pluvial 3
OutPort_3309887 | SOURCE | IF.SANE.Pluvial 3
InPort_3544069 | SINK | IF.SANE.Pluvial 3
OutPort_3309889 | SOURCE | IF.SANE.Pluvial 3
2 x InPort_3309927 | SOURCEANDSINK | IF.SANE.Fecal 7
2 x OutPort_3533250 | SOURCEANDSINK | IF.SANE.Fecal 7
OutPort_3543265 | SOURCEANDSINK | IF.SANE.Fecal 7
InPort_3310015 | SINK | IF.SANE.Pluvial 5
OutPort_3310013 | SOURCE | IF.SANE.Pluvial 5
InPort_3540289 | SINK | IF.SANE.Pluvial 5
OutPort_3310015 | SOURCE | IF.SANE.Pluvial 5
InPort_3534029 | SINK | IF.SANE.Pluvial 6
OutPort_3310100 | SOURCE | IF.SANE.Pluvial 6
InPort_3310174 | SINK | IF.SANE.Pluvial 11
OutPort_3310173 | SOURCE | IF.SANE.Pluvial 11
InPort_3539817 | SINK | IF.SANE.Pluvial 11
OutPort_3310174 | SOURCE | IF.SANE.Pluvial 11
2 x Port_3314028 | SOURCE
InPort_3356396 | SINK | IF.SANE.Fecal 7
OutPort_3314028 | SOURCE | IF.SANE.Fecal 7
InPort_3356417 | SINK | IF.SANE.Fecal 7
OutPort_3314081 | SOURCE | IF.SANE.Fecal 7
2 x Port_3314081 | SOURCE
2 x Port_3314111 | SOURCE
InPort_3356439 | SINK | IF.SANE.Fecal 7
OutPort_3314111 | SOURCE | IF.SANE.Fecal 7
2 x Port_3314207 | SOURCE
InPort_3356460 | SINK | IF.SANE.Fecal 3
OutPort_3314207 | SOURCE | IF.SANE.Fecal 3
Port_3318627 | SOURCE
InPort_3318627 | SOURCEANDSINK | IF.SANE.Fecal 7
OutPort_3351774 | SOURCEANDSINK | IF.SANE.Fecal 7
InPort_3318628 | SOURCEANDSINK | IF.SANE.Fecal 7
OutPort_3351752 | SOURCEANDSINK | IF.SANE.Fecal 7
Port_3318628 | SOURCE
InPort_3318629 | SOURCEANDSINK | IF.SANE.Fecal 7
OutPort_3351731 | SOURCEANDSINK | IF.SANE.Fecal 7
Port_3318629 | SOURCE
InPort_3356315 | SINK | IF.SANE.Fecal 3
OutPort_3318630 | SOURCE | IF.SANE.Fecal 3
2 x Port_3318630 | SOURCE
InPort_3356263 | SINK | IF.SANE.Fecal 3
OutPort_3318631 | SOURCE | IF.SANE.Fecal 3
2 x Port_3318631 | SOURCE
2 x Port_3318632 | SOURCE
InPort_3356336 | SINK | IF.SANE.Fecal 3
OutPort_3318632 | SOURCE | IF.SANE.Fecal 3
InPort_3533419 | SINK | IF.SANE.Fecal 15
OutPort_3318633 | SOURCE | IF.SANE.Fecal 15
2 x Port_3318633 | SOURCE
InPort_3318634 | SOURCEANDSINK | IF.SANE.Fecal 7
OutPort_3356165 | SOURCEANDSINK | IF.SANE.Fecal 7
3 x Port_3318636 | SOURCE
Port_3318636 | SINK
Port_3320993 | SINK
2 x Port_3320993 | SOURCE
InPort_3320993 | SINK | IF.SANE.Pluvial 5
OutPort_3540271 | SOURCE | IF.SANE.Pluvial 5
InPort_3351438 | SINK | IF.SANE.Pluvial 5
OutPort_3351437 | SOURCE | IF.SANE.Pluvial 5
InPort_3544186 | SINK | IF.SANE.Pluvial 5
OutPort_3351438 | SOURCE | IF.SANE.Pluvial 5
InPort_3351461 | SINK | IF.SANE.Pluvial 5
OutPort_3351460 | SOURCE | IF.SANE.Pluvial 5
InPort_3539821 | SINK | IF.SANE.Pluvial 5
OutPort_3351461 | SOURCE | IF.SANE.Pluvial 5
InPort_3351530 | SINK | IF.SANE.Pluvial 5
OutPort_3351529 | SOURCE | IF.SANE.Pluvial 5
InPort_3540187 | SINK | IF.SANE.Pluvial 5
OutPort_3351530 | SOURCE | IF.SANE.Pluvial 5
InPort_3351546 | SINK | IF.SANE.Pluvial 3
OutPort_3351545 | SOURCE | IF.SANE.Pluvial 3
InPort_3543871 | SINK | IF.SANE.Pluvial 3
OutPort_3351546 | SOURCE | IF.SANE.Pluvial 3
Port_3351596 | SOURCEANDSINK | IF.SANE.Fecal 7
InPort_3351596 | SOURCEANDSINK | IF.SANE.Fecal 7
2 x OutPort_3356855 | SOURCEANDSINK | IF.SANE.Fecal 7
InPort_3351731 | SOURCEANDSINK | IF.SANE.Fecal 7
OutPort_3533226 | SOURCEANDSINK | IF.SANE.Fecal 7
InPort_3351752 | SOURCEANDSINK | IF.SANE.Fecal 7
2 x OutPort_3533239 | SOURCEANDSINK | IF.SANE.Fecal 7
InPort_3351774 | SOURCEANDSINK | IF.SANE.Fecal 7
2 x OutPort_3533259 | SOURCEANDSINK | IF.SANE.Fecal 7
Port_3356141 | SOURCEANDSINK | IF.SANE.Fecal 7
InPort_3356141 | SOURCEANDSINK | IF.SANE.Fecal 7
2 x OutPort_3531729 | SOURCEANDSINK | IF.SANE.Fecal 7
InPort_3356165 | SOURCEANDSINK | IF.SANE.Fecal 7
2 x OutPort_3533367 | SOURCEANDSINK | IF.SANE.Fecal 7
InPort_3533285 | SINK | IF.SANE.Fecal 3
OutPort_3356263 | SOURCE | IF.SANE.Fecal 3
InPort_3540947 | SINK | IF.SANE.Fecal 3
OutPort_3356290 | SOURCE | IF.SANE.Fecal 3
InPort_3356290 | SINK | IF.SANE.Fecal 3
OutPort_3533297 | SOURCE | IF.SANE.Fecal 3
InPort_3533276 | SINK | IF.SANE.Fecal 3
OutPort_3356315 | SOURCE | IF.SANE.Fecal 3
InPort_3356378 | SINK | IF.SANE.Fecal 3
OutPort_3356336 | SOURCE | IF.SANE.Fecal 3
InPort_3356375 | SINK | IF.SANE.Fecal 3
OutPort_3356378 | SOURCE | IF.SANE.Fecal 3
InPort_3533336 | SINK | IF.SANE.Fecal 3
OutPort_3356375 | SOURCE | IF.SANE.Fecal 3
InPort_3356382 | SINK | IF.SANE.Fecal 3
OutPort_3533276 | SOURCE | IF.SANE.Fecal 3
InPort_3533301 | SINK | IF.SANE.Fecal 3
OutPort_3356382 | SOURCE | IF.SANE.Fecal 3
InPort_3356491 | SINK | IF.SANE.Fecal 7
OutPort_3356396 | SOURCE | IF.SANE.Fecal 7
InPort_3356484 | SINK | IF.SANE.Fecal 7
OutPort_3356417 | SOURCE | IF.SANE.Fecal 7
InPort_3357642 | SINK | IF.SANE.Fecal 7
OutPort_3356439 | SOURCE | IF.SANE.Fecal 7
InPort_3356498 | SINK | IF.SANE.Fecal 3
OutPort_3356460 | SOURCE | IF.SANE.Fecal 3
InPort_3356474 | SINK | IF.SANE.Fecal 7
OutPort_3357642 | SOURCE | IF.SANE.Fecal 7
InPort_3532670 | SINK | IF.SANE.Fecal 7
OutPort_3356474 | SOURCE | IF.SANE.Fecal 7
InPort_3532958 | SINK | IF.SANE.Fecal 7
OutPort_3356481 | SOURCE | IF.SANE.Fecal 7
InPort_3356481 | SINK | IF.SANE.Fecal 7
OutPort_3532655 | SOURCE | IF.SANE.Fecal 7
InPort_3532664 | SINK | IF.SANE.Fecal 7
OutPort_3356484 | SOURCE | IF.SANE.Fecal 7
InPort_3532300 | SINK | IF.SANE.Fecal 7
OutPort_3356488 | SOURCE | IF.SANE.Fecal 7
InPort_3356488 | SINK | IF.SANE.Fecal 7
OutPort_3356491 | SOURCE | IF.SANE.Fecal 7
InPort_3533090 | SINK | IF.SANE.Fecal 3
OutPort_3356495 | SOURCE | IF.SANE.Fecal 3
InPort_3356495 | SINK | IF.SANE.Fecal 3
OutPort_3356498 | SOURCE | IF.SANE.Fecal 3
InPort_3356772 | SOURCEANDSINK | IF.SANE.Fecal 7
OutPort_3357061 | SOURCEANDSINK | IF.SANE.Fecal 7
2 x InPort_3356847 | SOURCEANDSINK | IF.SANE.Fecal 7
2 x OutPort_3356983 | SOURCEANDSINK | IF.SANE.Fecal 7
2 x InPort_3356859 | SOURCEANDSINK | IF.SANE.Fecal 7
OutPort_3356979 | SOURCEANDSINK | IF.SANE.Fecal 7
InPort_3356979 | SOURCEANDSINK | IF.SANE.Fecal 7
3 x OutPort_3533827 | SOURCEANDSINK | IF.SANE.Fecal 7
InPort_3357061 | SOURCEANDSINK | IF.SANE.Fecal 7
2 x InPort_3357299 | SOURCEANDSINK | IF.SANE.Fecal 7
OutPort_3531725 | SOURCEANDSINK | IF.SANE.Fecal 7
2 x InPort_3359718 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3366251 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3365944 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3364771 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3365782 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3364790 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3365821 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3364798 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3365860 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3364838 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3366140 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3365562 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3366173 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3365570 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3366194 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3365578 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3366215 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3365590 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3366233 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3365782 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3365929 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3365783 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3365925 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3365821 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3365940 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3365822 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3365936 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3365860 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3365948 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3365861 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3365925 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3365937 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3365936 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3365945 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3365944 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3366140 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3366260 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3366173 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3366295 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3366194 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3366330 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3366215 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3369590 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3366233 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3370999 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3366251 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3366257 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3366254 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3366256 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3366256 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3366292 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3366289 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3366291 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3366291 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3366305 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3366305 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3366320 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3366317 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3366327 | SOURCEANDSINK | IF.FONT.AFS 5
3 x InPort_3366319 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3370924 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3369571 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3370961 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3370963 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3369588 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3370922 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3375685 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3701038 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3370924 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3370926 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3370926 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3370953 | SOURCEANDSINK | IF.FONT.AFS 5
3 x InPort_3370952 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3370973 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3370973 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3370988 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3370985 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3370996 | SOURCEANDSINK | IF.FONT.AFS 5
3 x InPort_3370987 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3775097 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3371011 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3701036 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3371149 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3704960 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3704835 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3371336 | SINK | IF.FONT.AFS 5
OutPort_3701507 | SOURCE | IF.FONT.AFS 5
InPort_3371357 | SINK | IF.FONT.AFS 5
OutPort_3371336 | SOURCE | IF.FONT.AFS 5
2 x InPort_3371357 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3371657 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3371358 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3371358 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3783642 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3371578 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3703733 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3375729 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3371657 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3703663 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3371676 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3704962 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3371720 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3704845 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3705083 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3371763 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3371801 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3371791 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3371809 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3703780 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3371801 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3371805 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3371802 | SOURCEANDSINK | IF.FONT.AFS 5
2 x InPort_3371851 | SOURCEANDSINK | IF.FONT.ACS 2
2 x OutPort_3374098 | SOURCEANDSINK | IF.FONT.ACS 2
2 x OutPort_3703776 | SOURCEANDSINK | IF.FONT.ACS 2
2 x InPort_3371888 | SOURCEANDSINK | IF.FONT.ACS 2
2 x OutPort_3703743 | SOURCEANDSINK | IF.FONT.ACS 2
OutPort_3375800 | SOURCEANDSINK | IF.FONT.ACS 2
InPort_3374053 | SOURCEANDSINK | IF.FONT.ACS 2
OutPort_3374090 | SOURCEANDSINK | IF.FONT.ACS 2
InPort_3374090 | SOURCEANDSINK | IF.FONT.ACS 2
2 x OutPort_3374094 | SOURCEANDSINK | IF.FONT.ACS 2
2 x InPort_3374091 | SOURCEANDSINK | IF.FONT.ACS 2
InPort_3375685 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3375687 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3375687 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3775376 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3375729 | SOURCEANDSINK | IF.FONT.AFS 5
OutPort_3375731 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3375731 | SOURCEANDSINK | IF.FONT.AFS 5
2 x OutPort_3703670 | SOURCEANDSINK | IF.FONT.AFS 5
InPort_3375800 | SOURCEANDSINK | IF.FONT.ACS 2
OutPort_3375802 | SOURCEANDSINK | IF.FONT.ACS 2
InPort_3375802 | SOURCEANDSINK | IF.FONT.ACS 2
OutPort_3703891 | SOURCEANDSINK | IF.FONT.ACS 2
Port_3378262 | SOURCEANDSINK
Port_3378322 | SOURCEANDSINK
Port_3378331 | SOURCEANDSINK
Port_3378346 | SOURCEANDSINK
Port_3378356 | SOURCEANDSINK
Port_3378432 | SOURCEANDSINK
Port_3378455 | SOURCEANDSINK
Port_3378478 | SOURCEANDSINK
Port_3378486 | SOURCEANDSINK
Port_3378494 | SOURCEANDSINK
Port_3378601 | SOURCEANDSINK
Port_3378670 | SOURCEANDSINK
Port_3378748 | SOURCEANDSINK
Port_3378766 | SOURCEANDSINK
Port_3378807 | SOURCEANDSINK
Port_3378839 | SOURCEANDSINK
Port_3378871 | SOURCEANDSINK
Port_3378879 | SOURCEANDSINK
Port_3378892 | SOURCEANDSINK
Port_3378929 | SOURCEANDSINK
Port_3379036 | SOURCEANDSINK
Port_3379070 | SOURCEANDSINK
Port_3379144 | SOURCEANDSINK
Port_3379166 | SOURCEANDSINK
Port_3379238 | SOURCEANDSINK
Port_3379281 | SOURCEANDSINK
Port_3379298 | SOURCEANDSINK
Port_3379308 | SOURCEANDSINK
Port_3379316 | SOURCEANDSINK
Port_3379372 | SOURCEANDSINK
Port_3379428 | SOURCEANDSINK
Port_3379455 | SOURCEANDSINK
Port_3379464 | SOURCEANDSINK
Port_3379472 | SOURCEANDSINK
Port_3379494 | SOURCEANDSINK
Port_3379495 | SOURCEANDSINK
Port_3379516 | SOURCEANDSINK
Port_3379524 | SOURCEANDSINK
Port_3382530 | SOURCEANDSINK
InPort_3387709 | SINK | IF.EXTI.BIEs 5
OutPort_3402873 | SOURCE | IF.EXTI.BIEs 5
InPort_3387782 | SINK | IF.EXTI.BIEs 5
OutPort_3402471 | SOURCE | IF.EXTI.BIEs 5
2 x InPort_3396681 | SOURCEANDSINK | IF.EXTI.BIEs 5
OutPort_3403581 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3403671 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3396760 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3402881 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3401225 | SOURCEANDSINK | IF.EXTI.BIEs 5
Port_3399407 | SOURCEANDSINK
2 x InPort_3400669 | SOURCEANDSINK | IF.EXTI.BIEs 5
OutPort_3403311 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3402728 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3401217 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3402931 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3401282 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3402739 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3402736 | SOURCEANDSINK | IF.EXTI.BIEs 5
InPort_3402471 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3402631 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3402502 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3402635 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3402610 | SOURCEANDSINK | IF.EXTI.BIEs 5
3 x InPort_3402727 | SOURCEANDSINK | IF.EXTI.BIEs 5
InPort_3402752 | SINK | IF.EXTI.BIEs 5
OutPort_3402839 | SOURCE | IF.EXTI.BIEs 5
InPort_3402770 | SINK | IF.EXTI.BIEs 5
OutPort_3402856 | SOURCE | IF.EXTI.BIEs 5
InPort_3402839 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3402925 | SOURCEANDSINK | IF.EXTI.BIEs 5
InPort_3402856 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3403513 | SOURCEANDSINK | IF.EXTI.BIEs 5
InPort_3402873 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3403071 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3402900 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3402935 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3402908 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3403041 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3403089 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3403081 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3403517 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3403110 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3403511 | SOURCEANDSINK | IF.EXTI.BIEs 5
InPort_3403311 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3403585 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3403376 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3783792 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3783768 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3403444 | SOURCEANDSINK | IF.EXTI.BIEs 5
OutPort_3783764 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3403490 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3403581 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3783708 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3403582 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3783706 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3403607 | SOURCEANDSINK | IF.EXTI.BIEs 5
OutPort_3563009 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3403814 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3403636 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3403667 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3403663 | SOURCEANDSINK | IF.EXTI.BIEs 5
OutPort_3403665 | SOURCEANDSINK | IF.EXTI.BIEs 5
InPort_3403665 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3563011 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3403681 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3403812 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3403712 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3403758 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3403720 | SOURCEANDSINK | IF.EXTI.BIEs 5
OutPort_3403743 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x InPort_3403737 | SOURCEANDSINK | IF.EXTI.BIEs 5
OutPort_3656174 | SOURCEANDSINK | IF.EXTI.BIEs 5
OutPort_3416065 | SOURCEANDSINK | IF.EXTI.BIEs 5
InPort_3403743 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3415986 | SOURCEANDSINK | IF.EXTI.BIEs 5
Port_3412135 | SOURCEANDSINK
2 x InPort_3415984 | SOURCEANDSINK | IF.EXTI.BIEs 5
2 x OutPort_3419661 | SOURCEANDSINK | IF.EXTI.BIEs 5
InPort_3416065 | SOURCEANDSINK | IF.EXTI.BIEs 5
OutPort_3416067 | SOURCEANDSINK | IF.EXTI.BIEs 5
InPort_3416067 | SOURCEANDSINK | IF.EXTI.BIEs 5
OutPort_3419659 | SOURCEANDSINK | IF.EXTI.BIEs 5
InPort_3419659 | SOURCEANDSINK | IF.EXTI.BIEs 5
InPort_3437729 | SOURCEANDSINK | IC.REF.Gas 2
2 x OutPort_3635838 | SOURCEANDSINK | IC.REF.Gas 2
Port_3437729 | SOURCEANDSINK
InPort_3437729 | SOURCEANDSINK | IC.REF.Liq 1
OutPort_3636033 | SOURCEANDSINK | IC.REF.Liq 1
Port_3437729 | SINK
Port_3437729 | SOURCEANDSINK | IC.REF.Gas 1
InPort_3471751 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3446550 | SOURCE | Mechanical IC.AIRE.Aportació 5
Port_3446550 | SOURCEANDSINK | Mechanical IC.AIRE.Aportació 5
InPort_3446550 | SOURCEANDSINK | Mechanical IC.AIRE.Aportació 5
2 x OutPort_3464208 | SOURCEANDSINK | Mechanical IC.AIRE.Aportació 5
2 x InPort_3446585 | SOURCEANDSINK | Mechanical IC.AIRE.Aportació 5
2 x OutPort_3464204 | SOURCEANDSINK | Mechanical IC.AIRE.Aportació 5
InPort_3446708 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3464200 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3464191 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3446708 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3447156 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3446758 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3446758 | SINK | Mechanical IC.AIRE.Aportació 5
2 x OutPort_3783155 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3446808 | SINK | Mechanical IC.AIRE.Aportació 5
2 x OutPort_3783172 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3447157 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3446808 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3447370 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3447117 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3447117 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3447157 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3447257 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3447156 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3447241 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3447260 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3471490 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3447241 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3447260 | SINK | Mechanical IC.AIRE.Aportació 5
2 x OutPort_3447256 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3783173 | SINK | Mechanical IC.AIRE.Aportació 5
InPort_3447256 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3447257 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3447331 | SINK | Mechanical IC.AIRE.Aportació 5
OutPort_3447370 | SOURCE | Mechanical IC.AIRE.Aportació 5
InPort_3447665 | SINK | Mechanical IC.AIRE.Aportació 5
