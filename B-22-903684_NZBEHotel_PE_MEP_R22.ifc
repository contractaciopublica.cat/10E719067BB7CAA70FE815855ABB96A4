Properties of the parts of a building model (IFC2X3), part 7 of 7

# IfcFlowTerminal: AMB_BIE_Armari1:AMB.PCI.BIEArmari (4)
Type - PredefinedType: HOSEREEL; Classification: 50.50.10.70 BIES (Uniformat); Material: Stainless Steel sheet, Red RAL 3000, Cuerpo y puerta en chapa de acero, espesor 1mm.
Type - Pset_ManufacturerTypeInformation - Manufacturer: EACI; ProductionYear: Monthly
Type - Pset_PackingInstructions - SpecialInstructions: Fragile
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Type - Pset_Warranty - IsExtendedWarranty: yes; Exclusions: Material not supplied by EACI and when the maintenance is not properly done, according to RIPCI & UNE-EN 671-3
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.50.10.70; 105.AMB.ClassificacioDescripcio: BIES; 109.AMB.CodiTipus: PCI05; 111.AMB.DescripcioTipus: Jet range of 10m at 2 bar
Type - 3 AMB.Fabricant - 301.AMB.Fabricant: EACI; 302.AMB.Model: BIE25L20
Type - 5 AMB.Geometria - 503.AMB.Altura: 65 cm
Type - Pset_FireSuppressionTerminalTypeHoseReel - InletConnectionSize: 2.54 cm; HoseDiameter: 2.5 cm; ClassOfService: First intervention; ClassificationAuthority: UNE-EN 671-1
Material: Cuerpo y puerta en chapa de acero, espesor 1mm., Stainless Steel sheet, Red RAL 3000, Acrylic, Clear, Plástico, Negro; Group: IF.EXTI.BIEs 5
Pset_DistributionFlowElementCommon - Reference: AMB_BIE_Armari1:AMB.PCI.BIEArmari; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_BIE_Armari1: AMB.PCI.BIEArmari; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.743634 m2; 509.AMB.Volum: 0.103515 m3
Name (AMB_BIE_Armari1:AMB.PCI.BIEArmari:...) | In | 115.AMB.Nivell
3387709 | P0 | Level: P0
3387782 | P0 | Level: P0
3402752 | P1 | Level: P1
3402770 | P1 | Level: P1

# IfcFlowTerminal: AMB_Bonera:AMB.SAN.BoneraPluvials.90mm (14)
Type - Classification: 50.20.20.60 Terminals de drenatge (Uniformat); Material: <Unnamed> (2)
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.60; 105.AMB.ClassificacioDescripcio: Terminals de drenatge; 109.AMB.CodiTipus: SAN06; 111.AMB.DescripcioTipus: Bonera pluvials 90 mm
Pset_DistributionFlowElementCommon - Reference: AMB_Bonera:AMB.SAN.BoneraPluvials.90mm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Bonera: AMB.SAN.BoneraPluvials.90mm; 112.AMB.Servei: Piping System: IF.SANE.Pluvial; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 509.AMB.Volum: 0.000474321 m3
Name (AMB_Bonera:AMB.SAN.BoneraPluvials.90mm:...) | In | Group | Material
3309747 | P2 | IF.SANE.Pluvial 3 | 1 AMB.Identificacio - 115.AMB.Nivell: Level: P2
3309887 | P2 | IF.SANE.Pluvial 3 | <Unnamed>
3310013 | P2 | IF.SANE.Pluvial 5 | <Unnamed>
3310100 | P2 | IF.SANE.Pluvial 6 | <Unnamed>
3310173 | P2 | IF.SANE.Pluvial 11 | <Unnamed>
3351437 | P2 | IF.SANE.Pluvial 5 | <Unnamed>
3351460 | P2 | IF.SANE.Pluvial 5 | <Unnamed>
3351529 | P2 | IF.SANE.Pluvial 5 | <Unnamed>
3351545 | P2 | IF.SANE.Pluvial 3 | <Unnamed>
3537688 | P2 | IF.SANE.Pluvial 6 | <Unnamed>
3537704 | P2 | IF.SANE.Pluvial 6 | <Unnamed>
3537719 | P2 | IF.SANE.Pluvial 11 | <Unnamed>
3537736 | P2 | IF.SANE.Pluvial 11 | <Unnamed>
3540474 | P0 | IF.SANE.Pluvial 7 | <Unnamed> | 1 AMB.Identificacio - 115.AMB.Nivell: Level: P0

# IfcFlowTerminal: AMB_INS_Reixeta_Impulsió:AMB.CLI.Reixeta.Impulsió.1000x150mm (6)
Type - Classification: 50.30.50.50 Reixetes (Uniformat); Material: Metal.Aluminum.Painted.White (68), Auxiliary.Black
Type - Pset_ProductRequirements - Category: Air Terminals
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.50.50; 105.AMB.ClassificacioDescripcio: Reixetes; 109.AMB.CodiTipus: CLI04; 111.AMB.DescripcioTipus: Difusor lineal marca TROX - mesuras segons projecte
Pset_DistributionFlowElementCommon - Reference: AMB_INS_Reixeta_Impulsió:AMB.CLI.Reixeta.Impulsió.1000x150mm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_INS_Reixeta_Impulsió: AMB.CLI.Reixeta.Impulsió.1000x150mm; 112.AMB.Servei: Duct System: IC.AIRE.Aportació; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.350738 m2; 509.AMB.Volum: 0.00073875 m3
Name (AMB_INS_Reixeta_Impulsió:AMB.CLI.Reixeta.Impulsió.1000x150mm:...) | In | 115.AMB.Nivell | Group | Material
3470310 | P0 | Level: P0 | Mechanical IC.AIRE.Aportació 5
3471642 | P0 | Level: P0 | Mechanical IC.AIRE.Aportació 5 | Metal.Aluminum.Painted.White, Auxiliary.Black
3697085 | P1 | Level: P1 | Mechanical IC.AIRE.Aportació 3 | Metal.Aluminum.Painted.White, Auxiliary.Black
3697086 | P1 | Level: P1 | Mechanical IC.AIRE.Aportació 3 | Metal.Aluminum.Painted.White, Auxiliary.Black
3697096 | P1 | Level: P1 | Mechanical IC.AIRE.Aportació 3 | Metal.Aluminum.Painted.White, Auxiliary.Black
3698076 | P1 | Level: P1 | Mechanical IC.AIRE.Aportació 3 | Metal.Aluminum.Painted.White, Auxiliary.Black

# IfcFlowTerminal: AMB_INS_Reixeta_Impulsió:AMB.CLI.Reixeta.Impulsió.250x100mm (5)
Type - Classification: 50.30.50.50 Reixetes (Uniformat); Material: Metal.Aluminum.Painted.White (18), Auxiliary.Black
Type - Pset_ProductRequirements - Category: Air Terminals
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.50.50; 105.AMB.ClassificacioDescripcio: Reixetes; 109.AMB.CodiTipus: CLI05; 111.AMB.DescripcioTipus: Difusor lineal marca TROX - mesuras segons projecte
Pset_DistributionFlowElementCommon - Reference: AMB_INS_Reixeta_Impulsió:AMB.CLI.Reixeta.Impulsió.250x100mm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_INS_Reixeta_Impulsió: AMB.CLI.Reixeta.Impulsió.250x100mm; 112.AMB.Servei: Duct System: IC.AIRE.Aportació; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.0711125 m2; 509.AMB.Volum: 0.00017375 m3
Name (AMB_INS_Reixeta_Impulsió:AMB.CLI.Reixeta.Impulsió.250x100mm:...) | In | 115.AMB.Nivell | Group | Material
3471475 | P0 | Level: P0 | Mechanical IC.AIRE.Aportació 5
3471488 | P0 | Level: P0 | Mechanical IC.AIRE.Aportació 5 | Metal.Aluminum.Painted.White, Auxiliary.Black
3471563 | P0 | Level: P0 | Mechanical IC.AIRE.Aportació 5 | Metal.Aluminum.Painted.White, Auxiliary.Black
3471751 | P0 | Level: P0 | Mechanical IC.AIRE.Aportació 5 | Metal.Aluminum.Painted.White, Auxiliary.Black
3699160 | P1 | Level: P1 | Mechanical IC.AIRE.Aportació 3 | Metal.Aluminum.Painted.White, Auxiliary.Black

# IfcFlowTerminal: AMB_INS_Reixeta_Impulsió:AMB.CLI.Reixeta.Impulsió.600x200mm (5)
Type - Classification: 50.30.50.50 Reixetes (Uniformat); Material: Metal.Aluminum.Painted.White (41), Auxiliary.Black
Type - Pset_ProductRequirements - Category: Air Terminals
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.50.50; 105.AMB.ClassificacioDescripcio: Reixetes; 109.AMB.CodiTipus: CLI21; 111.AMB.DescripcioTipus: Difusor lineal marca TROX - mesuras segons projecte
Pset_DistributionFlowElementCommon - Reference: AMB_INS_Reixeta_Impulsió:AMB.CLI.Reixeta.Impulsió.600x200mm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_INS_Reixeta_Impulsió: AMB.CLI.Reixeta.Impulsió.600x200mm; 112.AMB.Servei: Duct System: IC.AIRE.Aportació; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.273 m2; 509.AMB.Volum: 0.0005625 m3
Name (AMB_INS_Reixeta_Impulsió:AMB.CLI.Reixeta.Impulsió.600x200mm:...) | In | 115.AMB.Nivell | Group | Material
3699200 | P1 | Level: P1 | Mechanical IC.AIRE.Aportació 3
3782564 | P1 | Level: P1 | Mechanical IC.AIRE.Aportació 3 | Metal.Aluminum.Painted.White, Auxiliary.Black
3782892 | S1 | Level: S1 | Mechanical IC.AIRE.Aportació 5 | Metal.Aluminum.Painted.White, Auxiliary.Black
3783080 | P0 | Level: P0 | Mechanical IC.AIRE.Aportació 5 | Metal.Aluminum.Painted.White, Auxiliary.Black
3783094 | P0 | Level: P0 | Mechanical IC.AIRE.Aportació 5 | Metal.Aluminum.Painted.White, Auxiliary.Black

# IfcFlowTerminal: AMB_INS_Reixeta_Retorn:AMB.CLI.Reixeta.Retorn.900x500mm (2)
Type - Classification: 50.30.50.50 Reixetes (Uniformat); Material: Metal.Aluminum.Painted.White (61), Auxiliary.Black
Type - Pset_ProductRequirements - Category: Air Terminals
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.50.50; 105.AMB.ClassificacioDescripcio: Reixetes; 109.AMB.CodiTipus: CLI07; 111.AMB.DescripcioTipus: Reixeta de retorn marca TROX 400x200mm
Pset_DistributionFlowElementCommon - Reference: AMB_INS_Reixeta_Retorn:AMB.CLI.Reixeta.Retorn.900x500mm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_INS_Reixeta_Retorn: AMB.CLI.Reixeta.Retorn.900x500mm; 112.AMB.Servei: Duct System: IC.AIRE.ExtraccióPrimari; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 1.27925 m2; 509.AMB.Volum: 0.006125 m3
Name (AMB_INS_Reixeta_Retorn:AMB.CLI.Reixeta.Retorn.900x500mm:...) | In | 115.AMB.Nivell | Group
3781208 | S1 | Level: S1 | Mechanical IC.AIRE.ExtraccióPrimari 2
3781947 | P1 | Level: P1 | Mechanical IC.AIRE.ExtraccióPrimari 1 | Material: Metal.Aluminum.Painted.White, Auxiliary.Black

# IfcFlowTerminal: AMB_Llumenera_Adossada_ JDFU-30:AMB.LLU.Llumenera.JDFU-30 39W (96)
In: P0
Type - Classification: 50.60.50.20 Il·luminació interior (Uniformat); Material: Plástico - Policarbonato - Pantalla Iluminada - 4000K, Plástico - Policarbonato - Blanco Roto - D2-1109005
Type - Pset_ProductRequirements - Category: Lighting Fixtures
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.50.20; 105.AMB.ClassificacioDescripcio: Il·luminació interior; 109.AMB.CodiTipus: LLU02; 111.AMB.DescripcioTipus: Llumenera decorativa muntatge adossat JDFU-30 39W
Type - 3 AMB.Fabricant - 302.AMB.Model: JDFU-30 39W
Type - 5 AMB.Geometria - 503.AMB.Altura: 8 cm
Material: Plástico - Policarbonato - Pantalla Iluminada - 4000K
Pset_DistributionFlowElementCommon - Reference: AMB_Llumenera_Adossada_ JDFU-30:AMB.LLU.Llumenera.JDFU-30 39W; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Llumenera_Adossada_ JDFU-30: AMB.LLU.Llumenera.JDFU-30 39W; 113.AMB.IDCircuit: N/A; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 229.AMB.Dimmeritzacio: NO
5 AMB.Geometria - 507.AMB.Area: 0.286954 m2; 509.AMB.Volum: 0.00628317 m3
Name (AMB_Llumenera_Adossada_ JDFU-30:AMB.LLU.Llumenera.JDFU-30 39W:...) | 114.AMB.IDQuadre
3516824 | Quadre Planta Baixa (QPB)
3517017 | Quadre Planta Baixa (QPB)
3517028 | Quadre Planta Baixa (QPB)
3517038 | Quadre Planta Baixa (QPB)
3517050 | Quadre Planta Baixa (QPB)
3517058 | Quadre Planta Baixa (QPB)
3517066 | Quadre Planta Baixa (QPB)
3517074 | Quadre Planta Baixa (QPB)
3517082 | Quadre Planta Baixa (QPB)
3517092 | Quadre Planta Baixa (QPB)
3517102 | Quadre Planta Baixa (QPB)
3517110 | Quadre Planta Baixa (QPB)
3517248 | Quadre Planta Baixa (QPB)
3517286 | Quadre Planta Baixa (QPB)
3517296 | Quadre Planta Baixa (QPB)
3517304 | Quadre Planta Baixa (QPB)
3517312 | Quadre Planta Baixa (QPB)
3517322 | Quadre Planta Baixa (QPB)
3517330 | Quadre Planta Baixa (QPB)
3517340 | Quadre Planta Baixa (QPB)
3517350 | Quadre Planta Baixa (QPB)
3517392 | Quadre Planta Baixa (QPB)
3517400 | Quadre Planta Baixa (QPB)
3517410 | Quadre Planta Baixa (QPB)
3517424 | Quadre Planta Baixa (QPB)
3517432 | Quadre Planta Baixa (QPB)
3517444 | Quadre Planta Baixa (QPB)
3517456 | Quadre Planta Baixa (QPB)
3517468 | Quadre Planta Baixa (QPB)
3517476 | Quadre Planta Baixa (QPB)
3517488 | Quadre Planta Baixa (QPB)
3517498 | Quadre Planta Baixa (QPB)
3517506 | Quadre Planta Baixa (QPB)
3517552 | Quadre Planta Baixa (QPB)
3517562 | Quadre Planta Baixa (QPB)
3517690 | Quadre Planta Baixa (QPB)
3517785 | Quadre Planta Baixa (QPB)
3517798 | Quadre Planta Baixa (QPB)
3517808 | Quadre Planta Baixa (QPB)
3517819 | Quadre Planta Baixa (QPB)
3517831 | Quadre Planta Baixa (QPB)
3521225 | Quadre Planta Baixa (QPB)
3526474 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3526518 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3526529 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3526543 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3526551 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3526561 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3526569 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3526577 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3526589 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3526597 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3526605 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3526615 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3526645 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545343 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545351 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545359 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545369 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545379 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545387 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545401 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545413 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545427 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545435 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545445 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545455 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545463 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545475 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545487 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545495 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545505 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545515 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545523 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545531 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545574 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545584 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545592 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545606 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545614 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545622 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545634 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545644 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545654 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545662 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545670 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545684 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545694 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3545771 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3546667 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3546792 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3546803 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3546813 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3546821 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3546833 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3546841 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)

# IfcFlowTerminal: AMB_Llumenera_Adossada_ JDFU-30:AMB.LLU.Llumenera.JDFU-30 55W (9)
In: P0
Type - Classification: 50.60.50.20 Il·luminació interior (Uniformat); Material: Plástico - Policarbonato - Blanco Roto - D2-1109005, Plástico - Policarbonato - Pantalla Iluminada - 4000K
Type - Pset_ProductRequirements - Category: Lighting Fixtures
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.50.20; 105.AMB.ClassificacioDescripcio: Il·luminació interior; 109.AMB.CodiTipus: LLU03; 111.AMB.DescripcioTipus: Llumenera decorativa muntatge adossat JDFU-30 55W
Type - 3 AMB.Fabricant - 302.AMB.Model: JDFU-30 55W
Type - 5 AMB.Geometria - 503.AMB.Altura: 8 cm
Material: Plástico - Policarbonato - Pantalla Iluminada - 4000K
Pset_DistributionFlowElementCommon - Reference: AMB_Llumenera_Adossada_ JDFU-30:AMB.LLU.Llumenera.JDFU-30 55W; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Llumenera_Adossada_ JDFU-30: AMB.LLU.Llumenera.JDFU-30 55W; 113.AMB.IDCircuit: N/A; 114.AMB.IDQuadre: Quadre Planta Baixa (QPB); 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 229.AMB.Dimmeritzacio: NO
5 AMB.Geometria - 507.AMB.Area: 0.286954 m2; 509.AMB.Volum: 0.00628317 m3
Name (AMB_Llumenera_Adossada_ JDFU-30:AMB.LLU.Llumenera.JDFU-30 55W:...)
3517931
3518083
3518123
3518164
3518209
3518219
3518235
3518265
3518273

# IfcFlowTerminal: AMB_Llumenera_ApliquePared_NemesisLED:AMB.LLU.Llumenera.ApliqueParet.NemesisLED (16)
In: P0
Type - Classification: 50.60.50.10 Il·luminació exterior (Uniformat); Material: Plástico - Policarbonato - Pantalla Iluminada - 4000K, Plástico - Policarbonato - Blanco Roto - D2-1109005
Type - Pset_ProductRequirements - Category: Lighting Fixtures
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.50.10; 105.AMB.ClassificacioDescripcio: Il·luminació exterior; 109.AMB.CodiTipus: LLU01; 111.AMB.DescripcioTipus: Aplique muntat sobre paret Nemesis LED de LEDS C4
Type - 3 AMB.Fabricant - 302.AMB.Model: Nemesis LED
Type - 5 AMB.Geometria - 503.AMB.Altura: 7 cm
Pset_DistributionFlowElementCommon - Reference: AMB_Llumenera_ApliquePared_NemesisLED:AMB.LLU.Llumenera.ApliqueParet.NemesisLED; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Llumenera_ApliquePared_NemesisLED: AMB.LLU.Llumenera.ApliqueParet.NemesisLED; 113.AMB.IDCircuit: N/A; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 229.AMB.Dimmeritzacio: NO
5 AMB.Geometria - 507.AMB.Area: 0.0659 m2; 509.AMB.Volum: 0.0012908 m3
Name (AMB_Llumenera_ApliquePared_NemesisLED:AMB.LLU.Llumenera.ApliqueParet.NemesisLED:...) | 114.AMB.IDQuadre
3524146 | Quadre Planta Baixa (QPB)
3524160 | Quadre Planta Baixa (QPB)
3524474 | Quadre Planta Baixa (QPB)
3524570 | Quadre Planta Baixa (QPB)
3524973 | Quadre Planta Baixa (QPB)
3524975 | Quadre Planta Baixa (QPB)
3524976 | Quadre Planta Baixa (QPB)
3524978 | Quadre Planta Baixa (QPB)
3546290 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3546291 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3546292 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3546293 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3546314 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3546316 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3546317 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3546319 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)

# IfcFlowTerminal: AMB_Llumenera_Downlight_JBOB-LED:AMB.LLU.Llumenera.Downlight.JDOB LED 24W (71)
Type - Classification: 50.60.50.20 Il·luminació interior (Uniformat); Material: Plastic.Polycarbonate.Illuminated·display.4000K, Plastic.Polycarbonate.White
Type - Pset_ProductRequirements - Category: Lighting Fixtures
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.50.20; 105.AMB.ClassificacioDescripcio: Il·luminació interior; 109.AMB.CodiTipus: LLU04; 111.AMB.DescripcioTipus: Downlight per encastar JDOB LED 24W
Type - 3 AMB.Fabricant - 302.AMB.Model: JDOB LED 24W
Type - 5 AMB.Geometria - 503.AMB.Altura: 9 cm
Material: Plastic.Polycarbonate.White, Plastic.Polycarbonate.Illuminated·display.4000K
Pset_DistributionFlowElementCommon - Reference: AMB_Llumenera_Downlight_JBOB-LED:AMB.LLU.Llumenera.Downlight.JDOB LED 24W; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Llumenera_Downlight_JBOB-LED: AMB.LLU.Llumenera.Downlight.JDOB LED 24W; 113.AMB.IDCircuit: N/A; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 229.AMB.Dimmeritzacio: NO
5 AMB.Geometria - 507.AMB.Area: 0.0552777 m2; 509.AMB.Volum: 0.000772332 m3
Name (AMB_Llumenera_Downlight_JBOB-LED:AMB.LLU.Llumenera.Downlight.JDOB LED 24W:...) | In | 114.AMB.IDQuadre | 115.AMB.Nivell
3520599 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3521272 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3521280 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522118 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522127 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522137 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522145 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522167 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522177 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522187 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522195 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522203 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522213 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522221 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522235 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522265 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522408 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522426 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522437 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522446 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522456 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522498 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522513 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522527 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522537 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522545 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522599 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522609 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522619 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522631 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522639 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522647 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522658 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522666 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522674 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522684 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522694 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3522708 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3545826 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3545873 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3545882 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3545890 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3545900 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3545914 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3545924 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3545934 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3545946 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3545960 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3545973 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3545987 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3545995 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3546007 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3546019 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3546037 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3546047 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3546102 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3546113 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3546124 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3546134 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3546143 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3546166 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3546199 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3546207 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3546221 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3546247 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3546259 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3546267 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3772537 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3772591 | P0 | Quadre Planta Baixa (QPB) | Level: P0
3774954 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1
3774963 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1

# IfcFlowTerminal: AMB_Llumenera_Emergència:AMB.PCI.LlumEmergència.Empotrat.Sostre (20)
In: P0
Type - Classification: 50.60.50.30 Il·luminació d'emergència (Uniformat); Material: Plastic.Polycarbonate.Illuminated·display.4000K, Plastic.Polycarbonate.White
Type - Pset_ProductRequirements - Category: Lighting Fixtures
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.50.30; 105.AMB.ClassificacioDescripcio: Il·luminació d'emergència; 109.AMB.CodiTipus: LLU06; 111.AMB.DescripcioTipus: Llum d'emergència amb làmpada led, amb grau de protecció IP4X
Type - 5 AMB.Geometria - 503.AMB.Altura: 7.4 cm
Material: Plastic.Polycarbonate.White, Plastic.Polycarbonate.Illuminated·display.4000K
Pset_DistributionFlowElementCommon - Reference: AMB_Llumenera_Emergència:AMB.PCI.LlumEmergència.Empotrat.Sostre; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Llumenera_Emergència: AMB.PCI.LlumEmergència.Empotrat.Sostre; 113.AMB.IDCircuit: N/A; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 229.AMB.Dimmeritzacio: NO
5 AMB.Geometria - 507.AMB.Area: 0.217426 m2; 509.AMB.Volum: 0.00469276 m3
Name (AMB_Llumenera_Emergència:AMB.PCI.LlumEmergència.Empotrat.Sostre:...) | 114.AMB.IDQuadre
3555128 | Quadre Planta Baixa (QPB)
3555227 | Quadre Planta Baixa (QPB)
3555651 | Quadre Planta Baixa (QPB)
3555793 | Quadre Planta Baixa (QPB)
3555829 | Quadre Planta Baixa (QPB)
3556030 | Quadre Planta Baixa (QPB)
3556216 | Quadre Planta Baixa (QPB)
3556229 | Quadre Planta Baixa (QPB)
3556241 | Quadre Planta Baixa (QPB)
3556561 | Quadre Planta Baixa (QPB)
3556725 | Quadre Planta Baixa (QPB)
3557050 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3557052 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3557054 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3557058 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3557059 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3557061 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3557062 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3557063 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)
3557067 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)

# IfcFlowTerminal: AMB_Llumenera_Emergència:AMB.PCI.LlumEmergència.Empotrat.Sostre.Permanent (2)
In: P0
Type - Classification: 50.60.50.30 Il·luminació d'emergència (Uniformat); Material: Plastic.Polycarbonate.Illuminated·display.4000K, Plastic.Polycarbonate.White
Type - Pset_ProductRequirements - Category: Lighting Fixtures
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.50.30; 105.AMB.ClassificacioDescripcio: Il·luminació d'emergència; 109.AMB.CodiTipus: LLU07; 111.AMB.DescripcioTipus: Llum d'emergència amb làmpada led, amb grau de protecció IP4X
Type - 5 AMB.Geometria - 503.AMB.Altura: 7.4 cm
Material: Plastic.Polycarbonate.White, Plastic.Polycarbonate.Illuminated·display.4000K, <Unnamed>
Pset_DistributionFlowElementCommon - Reference: AMB_Llumenera_Emergència:AMB.PCI.LlumEmergència.Empotrat.Sostre.Permanent; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Llumenera_Emergència: AMB.PCI.LlumEmergència.Empotrat.Sostre.Permanent; 113.AMB.IDCircuit: N/A; 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 229.AMB.Dimmeritzacio: NO
5 AMB.Geometria - 507.AMB.Area: 0.217426 m2; 509.AMB.Volum: 0.00472772 m3
Name (AMB_Llumenera_Emergència:AMB.PCI.LlumEmergència.Empotrat.Sostre.Permanent:...) | 114.AMB.IDQuadre
3556358 | Quadre Planta Baixa (QPB)
3557272 | AMB.ELE.QUA.Subquadre Planta Primera (QPP)

# IfcFlowTerminal: AMB_Llumenera_Emergència_Superfície:AMB.PCI.LlumEmergència.Superfície.Paret (15)
Type - Classification: 50.60.50.30 Il·luminació d'emergència (Uniformat); Material: AMB.Plástico - Policarbonato - Blanco Roto - D2-1109005
Type - Pset_ProductRequirements - Category: Lighting Fixtures
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.50.30; 105.AMB.ClassificacioDescripcio: Il·luminació d'emergència; 109.AMB.CodiTipus: LLU05; 111.AMB.DescripcioTipus: Llumenera emergència superficie paret
Material: AMB.Plástico - Policarbonato - Blanco Roto - D2-1109005, AMB.Plástico - Policarbonato - Pantalla Iluminada - 4000K
Pset_DistributionFlowElementCommon - Reference: AMB_Llumenera_Emergència_Superfície:AMB.PCI.LlumEmergència.Superfície.Paret; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Llumenera_Emergència_Superfície: AMB.PCI.LlumEmergència.Superfície.Paret; 113.AMB.IDCircuit: N/A; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 229.AMB.Dimmeritzacio: NO
5 AMB.Geometria - 507.AMB.Area: 0.230847 m2; 509.AMB.Volum: 0.00423078 m3
Name (AMB_Llumenera_Emergència_Superfície:AMB.PCI.LlumEmergència.Superfície.Paret:...) | In | 114.AMB.IDQuadre | 115.AMB.Nivell | 503.AMB.Altura (cm)
3551556 | P0 | Quadre Planta Baixa (QPB) | Level: P0 | 230
3551699 | P0 | Quadre Planta Baixa (QPB) | Level: P0 | 310
3551855 | P0 | Quadre Planta Baixa (QPB) | Level: P0 | 230
3551871 | P0 | Quadre Planta Baixa (QPB) | Level: P0 | 230
3551889 | P0 | Quadre Planta Baixa (QPB) | Level: P0 | 230
3551927 | P0 | Quadre Planta Baixa (QPB) | Level: P0 | 230
3554989 | P0 | Quadre Planta Baixa (QPB) | Level: P0 | 230
3555973 | P0 | Quadre Planta Baixa (QPB) | Level: P0 | 230
3556525 | P0 | Quadre Planta Baixa (QPB) | Level: P0 | 230
3556866 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1 | 230
3556869 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1 | 230
3556871 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1 | 230
3556873 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1 | 230
3556874 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1 | 230
3556877 | P1 | AMB.ELE.QUA.Subquadre Planta Primera (QPP) | Level: P1 | 230

# IfcFlowTerminal: AMB_Llumenera_MiniUrban65_LAMP:AMB.LLU.Llumenera.MiniUrban65.LAMP (3)
In: P0
Type - Classification: 50.60.50.20 Il·luminació interior (Uniformat); Material: Origen de luz por defecto
Type - Pset_ProductRequirements - Category: Lighting Fixtures
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.50.20; 105.AMB.ClassificacioDescripcio: Il·luminació interior; 109.AMB.CodiTipus: LLU08; 111.AMB.DescripcioTipus: Llumenera Mini Urban 65 de Lamp
Type - 3 AMB.Fabricant - 302.AMB.Model: L07
Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: AMB_Llumenera_MiniUrban65_LAMP:AMB.LLU.Llumenera.MiniUrban65.LAMP; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Llumenera_MiniUrban65_LAMP: AMB.LLU.Llumenera.MiniUrban65.LAMP; 113.AMB.IDCircuit: N/A; 114.AMB.IDQuadre: Quadre Planta Baixa (QPB); 115.AMB.Nivell: Level: P0; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 229.AMB.Dimmeritzacio: NO
5 AMB.Geometria - 507.AMB.Area: 0.0543438 m2; 509.AMB.Volum: 0.00107221 m3
Name (AMB_Llumenera_MiniUrban65_LAMP:AMB.LLU.Llumenera.MiniUrban65.LAMP:...)
3526317
3551629
3556560

# IfcFlowTerminal: AMB_Reixeta_Extracció:AMB.CLI.Reixeta.Extracció.200x100mm (5)
Type - Classification: 50.30.50.50 Reixetes (Uniformat); Material: <Unnamed>, Auxiliar.Elemento.Rejilla.Horizontal
Type - Pset_ProductRequirements - Category: Air Terminals
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.50.50; 105.AMB.ClassificacioDescripcio: Reixetes; 109.AMB.CodiTipus: CLI23; 111.AMB.DescripcioTipus: Reixeta
Pset_DistributionFlowElementCommon - Reference: AMB_Reixeta_Extracció:AMB.CLI.Reixeta.Extracció.200x100mm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Reixeta_Extracció: AMB.CLI.Reixeta.Extracció.200x100mm; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.02134 m2; 509.AMB.Volum: 0.0001312 m3
Name (AMB_Reixeta_Extracció:AMB.CLI.Reixeta.Extracció.200x100mm:...) | In | 112.AMB.Servei | 115.AMB.Nivell | Group
3694962 | P0 | Duct System: IC.AIRE.Extracció.Serveis | Level: P0 | Mechanical IC.AIRE.Extracció.Serveis 3
3694987 | P0 | Duct System: IC.AIRE.Extracció.Serveis | Level: P0 | Mechanical IC.AIRE.Extracció.Serveis 2
3780031 | S1 | Duct System: IC.AIRE.Extracció | Level: S1 | Mechanical IC.AIRE.Extracció 1
3780450 | S1 | Duct System: IC.AIRE.Extracció | Level: S1 | Mechanical IC.AIRE.Extracció 2
3780785 | S1 | Duct System: IC.AIRE.Extracció.Serveis | Level: S1 | Mechanical IC.AIRE.Extracció.Serveis 1

# IfcFlowTerminal: AMB_Reixeta_Extracció:AMB.CLI.Reixeta.Extracció.250x100mm (9)
Type - Classification: 50.30.50.50 Reixetes (Uniformat); Material: <Unnamed>, Auxiliar.Elemento.Rejilla.Horizontal
Type - Pset_ProductRequirements - Category: Air Terminals
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.50.50; 105.AMB.ClassificacioDescripcio: Reixetes; 109.AMB.CodiTipus: CLI26; 111.AMB.DescripcioTipus: Reixeta extracció
Pset_DistributionFlowElementCommon - Reference: AMB_Reixeta_Extracció:AMB.CLI.Reixeta.Extracció.250x100mm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Reixeta_Extracció: AMB.CLI.Reixeta.Extracció.250x100mm; 112.AMB.Servei: Duct System: IC.AIRE.Extracció.Serveis; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.02604 m2; 509.AMB.Volum: 0.0001622 m3
Name (AMB_Reixeta_Extracció:AMB.CLI.Reixeta.Extracció.250x100mm:...) | In | 115.AMB.Nivell | Group
3695066 | P1 | Level: P1 | Mechanical IC.AIRE.Extracció.Serveis 6
3696696 | P1 | Level: P1 | Mechanical IC.AIRE.Extracció.Serveis 9
3696709 | P1 | Level: P1 | Mechanical IC.AIRE.Extracció.Serveis 9
3696732 | P1 | Level: P1 | Mechanical IC.AIRE.Extracció.Serveis 9
3696745 | P1 | Level: P1 | Mechanical IC.AIRE.Extracció.Serveis 9
3696920 | P0 | Level: P0 | Mechanical IC.AIRE.Extracció.Serveis 11
3696921 | P0 | Level: P0 | Mechanical IC.AIRE.Extracció.Serveis 11
3696922 | P0 | Level: P0 | Mechanical IC.AIRE.Extracció.Serveis 11
3696923 | P0 | Level: P0 | Mechanical IC.AIRE.Extracció.Serveis 11

# IfcFlowTerminal: AMB_Valvula_Punt_Consum_Aigua:AMB.LAM.ValvulaPuntConsum.G20xR20 (29)
Type - Classification: 50.10.20.10 Vàlvules i instruments de mesura i control de fluxe de fontaneria (Uniformat); Material: 192_192_192
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.10; 105.AMB.ClassificacioDescripcio: Vàlvules i instruments de mesura i control de fluxe de fontaneria; 109.AMB.CodiTipus: LAM14; 111.AMB.DescripcioTipus: Valvula punt de consum DN20
Type - 2 AMB.Caracteristiques - 242.AMB.Mida: G20
Material: 192_192_192, Render Material 255-255-255
Pset_DistributionFlowElementCommon - Reference: AMB_Valvula_Punt_Consum_Aigua:AMB.LAM.ValvulaPuntConsum.G20xR20; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: AMB_Valvula_Punt_Consum_Aigua: AMB.LAM.ValvulaPuntConsum.G20xR20; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 509.AMB.Volum: 0.0000316146 m3
Name (AMB_Valvula_Punt_Consum_Aigua:AMB.LAM.ValvulaPuntConsum.G20xR20:...) | In | 112.AMB.Servei | 115.AMB.Nivell | Group
3364771 | P0 | Piping System: IF.FONT.AFS | Level: P0 | IF.FONT.AFS 5
3364790 | P0 | Piping System: IF.FONT.AFS | Level: P0 | IF.FONT.AFS 5
3364798 | P0 | Piping System: IF.FONT.AFS | Level: P0 | IF.FONT.AFS 5
3364838 | P0 | Piping System: IF.FONT.AFS | Level: P0 | IF.FONT.AFS 5
3365562 | P0 | Piping System: IF.FONT.AFS | Level: P0 | IF.FONT.AFS 5
3365570 | P0 | Piping System: IF.FONT.AFS | Level: P0 | IF.FONT.AFS 5
3365578 | P0 | Piping System: IF.FONT.AFS | Level: P0 | IF.FONT.AFS 5
3365590 | P0 | Piping System: IF.FONT.AFS | Level: P0 | IF.FONT.AFS 5
3371763 | P0 | Piping System: IF.FONT.AFS | Level: P0 | IF.FONT.AFS 5
3374053 | P0 | Piping System: IF.FONT.ACS | Level: P0 | IF.FONT.ACS 2
3703908 | P0 | Piping System: IF.FONT.AFS | Level: P0 | IF.FONT.AFS 5
3703916 | P0 | Piping System: IF.FONT.ACS | Level: P0 | IF.FONT.ACS 2
3703938 | P0 | Piping System: IF.FONT.AFS | Level: P0 | IF.FONT.AFS 5
3703939 | P0 | Piping System: IF.FONT.ACS | Level: P0 | IF.FONT.ACS 2
3703961 | P0 | Piping System: IF.FONT.AFS | Level: P0 | IF.FONT.AFS 5
3703980 | P0 | Piping System: IF.FONT.AFS | Level: P0 | IF.FONT.AFS 5
3704012 | P0 | Piping System: IF.FONT.AFS | Level: P0 | IF.FONT.AFS 5
3709531 | P1 | Piping System: IF.FONT.AFS | Level: P1 | IF.FONT.AFS 5
3709532 | P1 | Piping System: IF.FONT.AFS | Level: P1 | IF.FONT.AFS 5
3709533 | P1 | Piping System: IF.FONT.AFS | Level: P1 | IF.FONT.AFS 5
3709534 | P1 | Piping System: IF.FONT.AFS | Level: P1 | IF.FONT.AFS 5
3709535 | P1 | Piping System: IF.FONT.AFS | Level: P1 | IF.FONT.AFS 5
3709536 | P1 | Piping System: IF.FONT.AFS | Level: P1 | IF.FONT.AFS 5
3709537 | P1 | Piping System: IF.FONT.AFS | Level: P1 | IF.FONT.AFS 5
3709538 | P1 | Piping System: IF.FONT.AFS | Level: P1 | IF.FONT.AFS 5
3710137 | P1 | Piping System: IF.FONT.AFS | Level: P1 | IF.FONT.AFS 5
3710138 | P1 | Piping System: IF.FONT.ACS | Level: P1 | IF.FONT.ACS 4
3710618 | P1 | Piping System: IF.FONT.AFS | Level: P1 | IF.FONT.AFS 5
3710619 | P1 | Piping System: IF.FONT.ACS | Level: P1 | IF.FONT.ACS 4
